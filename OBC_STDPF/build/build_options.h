//
// This file is generated by CMake @ 2026-09-18T17:04:47! Do not edit manually!
// The file is not meant to be included directly in your builds but is only used by the
// STM32 IDE to properly highlight the current build configuration! All defines here are automatically
// supplied to the compiler via command-line preprocessor defines and apply to the whole code base!
//

#ifndef BUILD_OPTIONS_H

#define GENERAL_EXEH_PERSIST_ENABLED
#define TELEMETRY_SERVICE_ENABLED
#define BEACONS_ENABLED
#define UHF_BEACONS_SINK_ENABLED
#define UHF_II_SUPPORT_ENABLED
#define SXBAND_SCHEDULER_ENABLED
#define COMM_ESPS_ENABLED
#define SXBAND_CRYPTO_ENABLED
#define CRYPTO_SERVICE_ENABLED
// #define LWIP_SUPPORT_ENABLED
// #define ETHERNET_SUPPORT_ENABLED
// #define SLIP_SUPPORT_ENABLED
// #define TFTPD_SUPPORT_ENABLED
#define MICROPYTHON_SERVICE_ENABLED
#define GNSS_ENABLED
#define CUBEADCS_GEN2_ENABLED
#define USE_CUSTOM_ESPS_MSG_DISPATCH_HANDLER
#define COMM_GW_ENABLED
// #define SDR_ENABLED
// #define ARDUCAM_ENABLED
#define FP_CSP_BINDER_ENABLED
// #define XBAND_FE_ENABLED
#define COMM_ESPS_MAC_PHY_ENABLED
#define COMM_RS485_MAC_LAYER_ENABLED
#define EXTMODULES_SBAND_TMTC_ENABLED
#define CSP_SUPPORT_ENABLED
#define DEBUG_LIB_ENABLED
#define DEBUG_MODE_WD_ENABLED
#define DEBUG_TRACE_FWUPD_ENABLED
// #define DEBUG_TRACE_MACDRV_ENABLED
// #define DEBUG_TRACE_CUBEADCS_ENABLED
// #define DEBUG_TRACE_OP_MODES_ENABLED
// #define DEBUG_TRACE_SDS_ENABLED
#define ES_TRACE_ENABLED
#define STM32_SWV_SUPPORT
#define FF_USE_WRITE
#define FF_USE_IOCTL
#define FFCONF_H "ffconf.h"
#define ES_TASK_STATS_ENABLED

#endif // BUILD_OPTIONS_H
