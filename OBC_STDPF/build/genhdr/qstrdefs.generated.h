// This file was automatically generated by makeqstrdata.py

QDEF(MP_QSTRnull, 0, 0, "")
QDEF(MP_QSTR_, 5381, 0, "")
QDEF(MP_QSTR___dir__, 36730, 7, "__dir__")
QDEF(MP_QSTR__0x0a_, 46511, 1, "\x0a")
QDEF(MP_QSTR__space_, 46469, 1, " ")
QDEF(MP_QSTR__star_, 46479, 1, "*")
QDEF(MP_QSTR__slash_, 46474, 1, "/")
QDEF(MP_QSTR__lt_module_gt_, 38077, 8, "<module>")
QDEF(MP_QSTR__, 46586, 1, "_")
QDEF(MP_QSTR___call__, 63911, 8, "__call__")
QDEF(MP_QSTR___class__, 50475, 9, "__class__")
QDEF(MP_QSTR___delitem__, 13821, 11, "__delitem__")
QDEF(MP_QSTR___enter__, 47725, 9, "__enter__")
QDEF(MP_QSTR___exit__, 63557, 8, "__exit__")
QDEF(MP_QSTR___getattr__, 63552, 11, "__getattr__")
QDEF(MP_QSTR___getitem__, 14630, 11, "__getitem__")
QDEF(MP_QSTR___hash__, 51447, 8, "__hash__")
QDEF(MP_QSTR___init__, 42335, 8, "__init__")
QDEF(MP_QSTR___int__, 6934, 7, "__int__")
QDEF(MP_QSTR___iter__, 13007, 8, "__iter__")
QDEF(MP_QSTR___len__, 45282, 7, "__len__")
QDEF(MP_QSTR___main__, 5006, 8, "__main__")
QDEF(MP_QSTR___module__, 12543, 10, "__module__")
QDEF(MP_QSTR___name__, 14562, 8, "__name__")
QDEF(MP_QSTR___new__, 5497, 7, "__new__")
QDEF(MP_QSTR___next__, 29442, 8, "__next__")
QDEF(MP_QSTR___qualname__, 107, 12, "__qualname__")
QDEF(MP_QSTR___repr__, 2832, 8, "__repr__")
QDEF(MP_QSTR___setitem__, 15922, 11, "__setitem__")
QDEF(MP_QSTR___str__, 52688, 7, "__str__")
QDEF(MP_QSTR_ArithmeticError, 35885, 15, "ArithmeticError")
QDEF(MP_QSTR_AssertionError, 23191, 14, "AssertionError")
QDEF(MP_QSTR_AttributeError, 56865, 14, "AttributeError")
QDEF(MP_QSTR_BaseException, 37383, 13, "BaseException")
QDEF(MP_QSTR_EOFError, 49041, 8, "EOFError")
QDEF(MP_QSTR_Ellipsis, 57584, 8, "Ellipsis")
QDEF(MP_QSTR_Exception, 10738, 9, "Exception")
QDEF(MP_QSTR_GeneratorExit, 25110, 13, "GeneratorExit")
QDEF(MP_QSTR_ImportError, 39968, 11, "ImportError")
QDEF(MP_QSTR_IndentationError, 8284, 16, "IndentationError")
QDEF(MP_QSTR_IndexError, 44419, 10, "IndexError")
QDEF(MP_QSTR_KeyError, 234, 8, "KeyError")
QDEF(MP_QSTR_KeyboardInterrupt, 58031, 17, "KeyboardInterrupt")
QDEF(MP_QSTR_LookupError, 27135, 11, "LookupError")
QDEF(MP_QSTR_MemoryError, 33756, 11, "MemoryError")
QDEF(MP_QSTR_NameError, 11706, 9, "NameError")
QDEF(MP_QSTR_NoneType, 26647, 8, "NoneType")
QDEF(MP_QSTR_NotImplementedError, 39110, 19, "NotImplementedError")
QDEF(MP_QSTR_OSError, 26017, 7, "OSError")
QDEF(MP_QSTR_OverflowError, 57729, 13, "OverflowError")
QDEF(MP_QSTR_RuntimeError, 61793, 12, "RuntimeError")
QDEF(MP_QSTR_StopIteration, 7402, 13, "StopIteration")
QDEF(MP_QSTR_SyntaxError, 36756, 11, "SyntaxError")
QDEF(MP_QSTR_SystemExit, 65312, 10, "SystemExit")
QDEF(MP_QSTR_TypeError, 38437, 9, "TypeError")
QDEF(MP_QSTR_ValueError, 34710, 10, "ValueError")
QDEF(MP_QSTR_ZeroDivisionError, 10166, 17, "ZeroDivisionError")
QDEF(MP_QSTR_abs, 12949, 3, "abs")
QDEF(MP_QSTR_all, 13124, 3, "all")
QDEF(MP_QSTR_any, 13075, 3, "any")
QDEF(MP_QSTR_append, 38763, 6, "append")
QDEF(MP_QSTR_args, 50882, 4, "args")
QDEF(MP_QSTR_bool, 15595, 4, "bool")
QDEF(MP_QSTR_builtins, 12791, 8, "builtins")
QDEF(MP_QSTR_bytearray, 41846, 9, "bytearray")
QDEF(MP_QSTR_bytecode, 32034, 8, "bytecode")
QDEF(MP_QSTR_bytes, 45660, 5, "bytes")
QDEF(MP_QSTR_callable, 28685, 8, "callable")
QDEF(MP_QSTR_chr, 19676, 3, "chr")
QDEF(MP_QSTR_classmethod, 36020, 11, "classmethod")
QDEF(MP_QSTR_clear, 41084, 5, "clear")
QDEF(MP_QSTR_close, 26419, 5, "close")
QDEF(MP_QSTR_const, 65472, 5, "const")
QDEF(MP_QSTR_copy, 56288, 4, "copy")
QDEF(MP_QSTR_count, 19878, 5, "count")
QDEF(MP_QSTR_dict, 64575, 4, "dict")
QDEF(MP_QSTR_dir, 7930, 3, "dir")
QDEF(MP_QSTR_divmod, 1208, 6, "divmod")
QDEF(MP_QSTR_end, 8970, 3, "end")
QDEF(MP_QSTR_endswith, 41755, 8, "endswith")
QDEF(MP_QSTR_eval, 42651, 4, "eval")
QDEF(MP_QSTR_exec, 49182, 4, "exec")
QDEF(MP_QSTR_extend, 59491, 6, "extend")
QDEF(MP_QSTR_find, 13312, 4, "find")
QDEF(MP_QSTR_format, 13094, 6, "format")
QDEF(MP_QSTR_from_bytes, 29749, 10, "from_bytes")
QDEF(MP_QSTR_get, 15155, 3, "get")
QDEF(MP_QSTR_getattr, 6080, 7, "getattr")
QDEF(MP_QSTR_globals, 18845, 7, "globals")
QDEF(MP_QSTR_hasattr, 45196, 7, "hasattr")
QDEF(MP_QSTR_hash, 28855, 4, "hash")
QDEF(MP_QSTR_id, 28456, 2, "id")
QDEF(MP_QSTR_index, 10363, 5, "index")
QDEF(MP_QSTR_insert, 21522, 6, "insert")
QDEF(MP_QSTR_int, 21270, 3, "int")
QDEF(MP_QSTR_isalpha, 14315, 7, "isalpha")
QDEF(MP_QSTR_isdigit, 39592, 7, "isdigit")
QDEF(MP_QSTR_isinstance, 48822, 10, "isinstance")
QDEF(MP_QSTR_islower, 33020, 7, "islower")
QDEF(MP_QSTR_isspace, 63579, 7, "isspace")
QDEF(MP_QSTR_issubclass, 32693, 10, "issubclass")
QDEF(MP_QSTR_isupper, 42973, 7, "isupper")
QDEF(MP_QSTR_items, 21475, 5, "items")
QDEF(MP_QSTR_iter, 8591, 4, "iter")
QDEF(MP_QSTR_join, 23719, 4, "join")
QDEF(MP_QSTR_key, 27954, 3, "key")
QDEF(MP_QSTR_keys, 4865, 4, "keys")
QDEF(MP_QSTR_len, 16482, 3, "len")
QDEF(MP_QSTR_list, 7463, 4, "list")
QDEF(MP_QSTR_little, 27273, 6, "little")
QDEF(MP_QSTR_locals, 41275, 6, "locals")
QDEF(MP_QSTR_lower, 52166, 5, "lower")
QDEF(MP_QSTR_lstrip, 47589, 6, "lstrip")
QDEF(MP_QSTR_main, 47054, 4, "main")
QDEF(MP_QSTR_map, 17337, 3, "map")
QDEF(MP_QSTR_micropython, 31755, 11, "micropython")
QDEF(MP_QSTR_next, 34882, 4, "next")
QDEF(MP_QSTR_object, 36240, 6, "object")
QDEF(MP_QSTR_open, 15057, 4, "open")
QDEF(MP_QSTR_ord, 24092, 3, "ord")
QDEF(MP_QSTR_pop, 29482, 3, "pop")
QDEF(MP_QSTR_popitem, 11455, 7, "popitem")
QDEF(MP_QSTR_pow, 29485, 3, "pow")
QDEF(MP_QSTR_print, 50772, 5, "print")
QDEF(MP_QSTR_range, 24090, 5, "range")
QDEF(MP_QSTR_read, 63927, 4, "read")
QDEF(MP_QSTR_readinto, 48971, 8, "readinto")
QDEF(MP_QSTR_readline, 6649, 8, "readline")
QDEF(MP_QSTR_remove, 35427, 6, "remove")
QDEF(MP_QSTR_replace, 9545, 7, "replace")
QDEF(MP_QSTR_repr, 63440, 4, "repr")
QDEF(MP_QSTR_reverse, 10789, 7, "reverse")
QDEF(MP_QSTR_rfind, 40146, 5, "rfind")
QDEF(MP_QSTR_rindex, 11241, 6, "rindex")
QDEF(MP_QSTR_round, 9703, 5, "round")
QDEF(MP_QSTR_rsplit, 165, 6, "rsplit")
QDEF(MP_QSTR_rstrip, 38203, 6, "rstrip")
QDEF(MP_QSTR_self, 30585, 4, "self")
QDEF(MP_QSTR_send, 30393, 4, "send")
QDEF(MP_QSTR_sep, 36643, 3, "sep")
QDEF(MP_QSTR_set, 36647, 3, "set")
QDEF(MP_QSTR_setattr, 43220, 7, "setattr")
QDEF(MP_QSTR_setdefault, 41836, 10, "setdefault")
QDEF(MP_QSTR_sort, 40383, 4, "sort")
QDEF(MP_QSTR_sorted, 5470, 6, "sorted")
QDEF(MP_QSTR_split, 13239, 5, "split")
QDEF(MP_QSTR_start, 61317, 5, "start")
QDEF(MP_QSTR_startswith, 59508, 10, "startswith")
QDEF(MP_QSTR_staticmethod, 44898, 12, "staticmethod")
QDEF(MP_QSTR_step, 13911, 4, "step")
QDEF(MP_QSTR_stop, 13981, 4, "stop")
QDEF(MP_QSTR_str, 36176, 3, "str")
QDEF(MP_QSTR_strip, 7721, 5, "strip")
QDEF(MP_QSTR_sum, 36142, 3, "sum")
QDEF(MP_QSTR_super, 45764, 5, "super")
QDEF(MP_QSTR_throw, 17587, 5, "throw")
QDEF(MP_QSTR_to_bytes, 16088, 8, "to_bytes")
QDEF(MP_QSTR_tuple, 16893, 5, "tuple")
QDEF(MP_QSTR_type, 32669, 4, "type")
QDEF(MP_QSTR_update, 30388, 6, "update")
QDEF(MP_QSTR_upper, 37927, 5, "upper")
QDEF(MP_QSTR_utf_hyphen_8, 33463, 5, "utf-8")
QDEF(MP_QSTR_value, 13390, 5, "value")
QDEF(MP_QSTR_values, 48765, 6, "values")
QDEF(MP_QSTR_write, 43160, 5, "write")
QDEF(MP_QSTR_zip, 44262, 3, "zip")
QDEF(MP_QSTR___add__, 33476, 7, "__add__")
QDEF(MP_QSTR___bases__, 12291, 9, "__bases__")
QDEF(MP_QSTR___bool__, 25899, 8, "__bool__")
QDEF(MP_QSTR___build_class__, 34882, 15, "__build_class__")
QDEF(MP_QSTR___complex__, 58053, 11, "__complex__")
QDEF(MP_QSTR___contains__, 24518, 12, "__contains__")
QDEF(MP_QSTR___del__, 14184, 7, "__del__")
QDEF(MP_QSTR___dict__, 21631, 8, "__dict__")
QDEF(MP_QSTR___eq__, 15985, 6, "__eq__")
QDEF(MP_QSTR___file__, 21507, 8, "__file__")
QDEF(MP_QSTR___float__, 28725, 9, "__float__")
QDEF(MP_QSTR___ge__, 18087, 6, "__ge__")
QDEF(MP_QSTR___gt__, 33462, 6, "__gt__")
QDEF(MP_QSTR___iadd__, 19053, 8, "__iadd__")
QDEF(MP_QSTR___import__, 15928, 10, "__import__")
QDEF(MP_QSTR___isub__, 30728, 8, "__isub__")
QDEF(MP_QSTR___le__, 5068, 6, "__le__")
QDEF(MP_QSTR___lt__, 26717, 6, "__lt__")
QDEF(MP_QSTR___ne__, 2830, 6, "__ne__")
QDEF(MP_QSTR___path__, 9160, 8, "__path__")
QDEF(MP_QSTR___repl_print__, 47872, 14, "__repl_print__")
QDEF(MP_QSTR___reversed__, 65377, 12, "__reversed__")
QDEF(MP_QSTR___sub__, 2337, 7, "__sub__")
QDEF(MP_QSTR___traceback__, 53071, 13, "__traceback__")
QDEF(MP_QSTR__percent__hash_o, 6764, 3, "%#o")
QDEF(MP_QSTR__percent__hash_x, 6779, 3, "%#x")
QDEF(MP_QSTR__brace_open__colon__hash_b_brace_close_, 14168, 5, "{:#b}")
QDEF(MP_QSTR_maximum_space_recursion_space_depth_space_exceeded, 7795, 32, "maximum recursion depth exceeded")
QDEF(MP_QSTR__lt_lambda_gt_, 35968, 8, "<lambda>")
QDEF(MP_QSTR__lt_listcomp_gt_, 5588, 10, "<listcomp>")
QDEF(MP_QSTR__lt_dictcomp_gt_, 36300, 10, "<dictcomp>")
QDEF(MP_QSTR__lt_setcomp_gt_, 20820, 9, "<setcomp>")
QDEF(MP_QSTR__lt_genexpr_gt_, 27188, 9, "<genexpr>")
QDEF(MP_QSTR__lt_string_gt_, 21330, 8, "<string>")
QDEF(MP_QSTR__lt_stdin_gt_, 25571, 7, "<stdin>")
QDEF(MP_QSTR__dot_frozen, 62593, 7, ".frozen")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_0, 3734, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_0")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_1, 3735, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_1")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_2, 3732, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_2")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_3, 3733, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_FSS_3")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_HSS_0, 56728, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_HSS_0")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_HSS_1, 56729, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_HSS_1")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_STR_0, 18149, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_STR_0")
QDEF(MP_QSTR_ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_STR_1, 18148, 66, "ABSTRACTIMAGINGNODETYPE_TYPES_COMMON_FRAMEWORK_TYPES_1__NODE_STR_1")
QDEF(MP_QSTR_ADCSOPSTATE_OPSTATEAUTO, 62272, 23, "ADCSOPSTATE_OPSTATEAUTO")
QDEF(MP_QSTR_ADCSOPSTATE_OPSTATEFAULT, 57445, 24, "ADCSOPSTATE_OPSTATEFAULT")
QDEF(MP_QSTR_ADCSOPSTATE_OPSTATEMANUAL, 7221, 25, "ADCSOPSTATE_OPSTATEMANUAL")
QDEF(MP_QSTR_ADCSOPSTATE_OPSTATESAFE, 36702, 23, "ADCSOPSTATE_OPSTATESAFE")
QDEF(MP_QSTR_ADCSPROGTYPE_APPLICATION, 16903, 24, "ADCSPROGTYPE_APPLICATION")
QDEF(MP_QSTR_ADCSPROGTYPE_BOOTLOADER, 51994, 23, "ADCSPROGTYPE_BOOTLOADER")
QDEF(MP_QSTR_ADCSRUNMODE_ADCSENABLED, 21749, 23, "ADCSRUNMODE_ADCSENABLED")
QDEF(MP_QSTR_ADCSRUNMODE_ADCSOFF, 10911, 19, "ADCSRUNMODE_ADCSOFF")
QDEF(MP_QSTR_ADCSRUNMODE_ADCSSIMULATION, 31715, 26, "ADCSRUNMODE_ADCSSIMULATION")
QDEF(MP_QSTR_ADCSRUNMODE_ADCSTRIGGERED, 42217, 25, "ADCSRUNMODE_ADCSTRIGGERED")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_3AXIS, 54666, 26, "AOCSSTATE_AOCS_STATE_3AXIS")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_EXISTING_CONTROL, 1681, 37, "AOCSSTATE_AOCS_STATE_EXISTING_CONTROL")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_FAST_DETUMBLING, 15270, 36, "AOCSSTATE_AOCS_STATE_FAST_DETUMBLING")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_NORMAL_DETUMBLING, 13781, 38, "AOCSSTATE_AOCS_STATE_NORMAL_DETUMBLING")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_NO_CONTROL, 27523, 31, "AOCSSTATE_AOCS_STATE_NO_CONTROL")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_SUN_TRACKING, 5762, 33, "AOCSSTATE_AOCS_STATE_SUN_TRACKING")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_TARGET_TRACKING, 27963, 36, "AOCSSTATE_AOCS_STATE_TARGET_TRACKING")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_UNDEFINED, 19712, 30, "AOCSSTATE_AOCS_STATE_UNDEFINED")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_USER1, 62714, 26, "AOCSSTATE_AOCS_STATE_USER1")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_USER2, 62713, 26, "AOCSSTATE_AOCS_STATE_USER2")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_USER3, 62712, 26, "AOCSSTATE_AOCS_STATE_USER3")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_VERY_FAST_DETUMBLING, 60289, 41, "AOCSSTATE_AOCS_STATE_VERY_FAST_DETUMBLING")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_Y_MOMENTUM, 21876, 31, "AOCSSTATE_AOCS_STATE_Y_MOMENTUM")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_Y_MOMENTUM_FULL_STATE_EKF, 51719, 46, "AOCSSTATE_AOCS_STATE_Y_MOMENTUM_FULL_STATE_EKF")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_Y_THOMSON, 14992, 30, "AOCSSTATE_AOCS_STATE_Y_THOMSON")
QDEF(MP_QSTR_AOCSSTATE_AOCS_STATE_Y_THOMSON_MEMS_RATE, 1636, 40, "AOCSSTATE_AOCS_STATE_Y_THOMSON_MEMS_RATE")
QDEF(MP_QSTR_AbstractImagingNodeType, 16383, 23, "AbstractImagingNodeType")
QDEF(MP_QSTR_AdcsOpState, 6104, 11, "AdcsOpState")
QDEF(MP_QSTR_AdcsOpState_make_from_buf, 23714, 25, "AdcsOpState_make_from_buf")
QDEF(MP_QSTR_AdcsProgType, 14722, 12, "AdcsProgType")
QDEF(MP_QSTR_AdcsRunMode, 62810, 11, "AdcsRunMode")
QDEF(MP_QSTR_AdcsRunMode_make_from_buf, 54304, 25, "AdcsRunMode_make_from_buf")
QDEF(MP_QSTR_AocsRefParams, 27574, 13, "AocsRefParams")
QDEF(MP_QSTR_AocsRefParams_make_from_buf, 2764, 27, "AocsRefParams_make_from_buf")
QDEF(MP_QSTR_AocsState, 12428, 9, "AocsState")
QDEF(MP_QSTR_BOOTRESETREASON_RESETASSERTERR, 31599, 30, "BOOTRESETREASON_RESETASSERTERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTLOADERBANKSYNCERR, 60843, 42, "BOOTRESETREASON_RESETBOOTLOADERBANKSYNCERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTLOADEREXITERR, 58154, 38, "BOOTRESETREASON_RESETBOOTLOADEREXITERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTPINDIS, 37751, 31, "BOOTRESETREASON_RESETBOOTPINDIS")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTPINDISERR, 50258, 34, "BOOTRESETREASON_RESETBOOTPINDISERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTPINEN, 48770, 30, "BOOTRESETREASON_RESETBOOTPINEN")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBOOTPINENERR, 17799, 33, "BOOTRESETREASON_RESETBOOTPINENERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETBROWNOUT, 16416, 29, "BOOTRESETREASON_RESETBROWNOUT")
QDEF(MP_QSTR_BOOTRESETREASON_RESETCFGUNLOCK, 63418, 30, "BOOTRESETREASON_RESETCFGUNLOCK")
QDEF(MP_QSTR_BOOTRESETREASON_RESETCFGUNLOCKERR, 41023, 33, "BOOTRESETREASON_RESETCFGUNLOCKERR")
QDEF(MP_QSTR_BOOTRESETREASON_RESETENTERBOOTLOADER, 17767, 36, "BOOTRESETREASON_RESETENTERBOOTLOADER")
QDEF(MP_QSTR_BOOTRESETREASON_RESETEXTPIN, 57910, 27, "BOOTRESETREASON_RESETEXTPIN")
QDEF(MP_QSTR_BOOTRESETREASON_RESETFIREWALL, 26566, 29, "BOOTRESETREASON_RESETFIREWALL")
QDEF(MP_QSTR_BOOTRESETREASON_RESETLOWPOWER, 61571, 29, "BOOTRESETREASON_RESETLOWPOWER")
QDEF(MP_QSTR_BOOTRESETREASON_RESETOBL, 33385, 24, "BOOTRESETREASON_RESETOBL")
QDEF(MP_QSTR_BOOTRESETREASON_RESETSOFT, 45382, 25, "BOOTRESETREASON_RESETSOFT")
QDEF(MP_QSTR_BOOTRESETREASON_RESETUNKNOWN, 44288, 28, "BOOTRESETREASON_RESETUNKNOWN")
QDEF(MP_QSTR_BOOTRESETREASON_RESETWATCHDOG, 5165, 29, "BOOTRESETREASON_RESETWATCHDOG")
QDEF(MP_QSTR_BOOTRESETREASON_RESETWRPCLEARALL, 39141, 32, "BOOTRESETREASON_RESETWRPCLEARALL")
QDEF(MP_QSTR_BOOTRESETREASON_RESETWRPCLEARALLERR, 8064, 35, "BOOTRESETREASON_RESETWRPCLEARALLERR")
QDEF(MP_QSTR_BOOTSTATE_APPLICATIONRUNNING, 21094, 28, "BOOTSTATE_APPLICATIONRUNNING")
QDEF(MP_QSTR_BOOTSTATE_ASSERTERROR, 5633, 21, "BOOTSTATE_ASSERTERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERAUTODISCOVER, 22944, 32, "BOOTSTATE_BOOTLOADERAUTODISCOVER")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERAUTODISCOVERERROR, 48216, 37, "BOOTSTATE_BOOTLOADERAUTODISCOVERERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBACKOFF, 2552, 27, "BOOTSTATE_BOOTLOADERBACKOFF")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBANKSYNCERROR, 3781, 33, "BOOTSTATE_BOOTLOADERBANKSYNCERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBOOTPINDIS, 58531, 30, "BOOTSTATE_BOOTLOADERBOOTPINDIS")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBOOTPINDISERROR, 7803, 35, "BOOTSTATE_BOOTLOADERBOOTPINDISERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBOOTPINEN, 1750, 29, "BOOTSTATE_BOOTLOADERBOOTPINEN")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERBOOTPINENERROR, 12974, 34, "BOOTSTATE_BOOTLOADERBOOTPINENERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERCFGUNLOCK, 62446, 29, "BOOTSTATE_BOOTLOADERCFGUNLOCK")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERCFGUNLOCKERROR, 53334, 34, "BOOTSTATE_BOOTLOADERCFGUNLOCKERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADEREXITERROR, 1092, 29, "BOOTSTATE_BOOTLOADEREXITERROR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERHALT, 5549, 24, "BOOTSTATE_BOOTLOADERHALT")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERHALTRESET, 3160, 29, "BOOTSTATE_BOOTLOADERHALTRESET")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERJUMP, 47710, 24, "BOOTSTATE_BOOTLOADERJUMP")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERPORTVALIDATION, 26766, 34, "BOOTSTATE_BOOTLOADERPORTVALIDATION")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERRUNNING, 55835, 27, "BOOTSTATE_BOOTLOADERRUNNING")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERWRPCLEAR, 4144, 28, "BOOTSTATE_BOOTLOADERWRPCLEAR")
QDEF(MP_QSTR_BOOTSTATE_BOOTLOADERWRPCLEARERROR, 2248, 33, "BOOTSTATE_BOOTLOADERWRPCLEARERROR")
QDEF(MP_QSTR_BootResetReason, 450, 15, "BootResetReason")
QDEF(MP_QSTR_BootState, 34148, 9, "BootState")
QDEF(MP_QSTR_BootStatus, 13191, 10, "BootStatus")
QDEF(MP_QSTR_BootStatus_make_from_buf, 34813, 24, "BootStatus_make_from_buf")
QDEF(MP_QSTR_BytesIO, 46874, 7, "BytesIO")
QDEF(MP_QSTR_CMDTARGETNODE_NODECOMPUTER, 18278, 26, "CMDTARGETNODE_NODECOMPUTER")
QDEF(MP_QSTR_CMDTARGETNODE_NODEINVALID, 13968, 25, "CMDTARGETNODE_NODEINVALID")
QDEF(MP_QSTR_COMMISSIONINGSTATUS_CMS_STATUS_COMPLETE, 56835, 39, "COMMISSIONINGSTATUS_CMS_STATUS_COMPLETE")
QDEF(MP_QSTR_COMMISSIONINGSTATUS_CMS_STATUS_NOT_DONE, 36544, 39, "COMMISSIONINGSTATUS_CMS_STATUS_NOT_DONE")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECOMPUTER, 17769, 47, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECOMPUTER")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ0, 60972, 42, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ1, 60973, 42, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ2, 60974, 42, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ2")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ3, 60975, 42, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODECQ3")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXT0, 41591, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXT0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXT1, 41590, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXT1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXTGYR0, 53947, 46, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXTGYR0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXTGYR1, 53946, 46, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEEXTGYR1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS0, 6840, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS1, 6841, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS2, 6842, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS2")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS3, 6843, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEFSS3")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEHSS0, 53494, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEHSS0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEHSS1, 53495, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEHSS1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEINVALID, 56703, 46, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEINVALID")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEMAG0, 6869, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEMAG0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEMAG1, 6868, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODEMAG1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL0, 31447, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL1, 31446, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL2, 31445, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL2")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL3, 31444, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL3")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL4, 31443, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODERWL4")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODESTR0, 60779, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODESTR0")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODESTR1, 60778, 43, "COMMONFRAMEWORKTYPES1_ABSTRACTNODE_NODESTR1")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEAURIGA, 32502, 49, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEAURIGA")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBECOMPUTER, 34872, 51, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBECOMPUTER")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEIR, 18564, 45, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEIR")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEMAGCOMPACT, 7027, 53, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEMAGCOMPACT")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEMAGDEPLOY, 19551, 52, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEMAGDEPLOY")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODE, 26623, 47, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODE")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODENSSRWL, 43960, 53, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODENSSRWL")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEPST3S, 22888, 52, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEPST3S")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUAD, 830, 51, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUAD")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADLITEFUFORS, 2673, 61, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADLITEFUFORS")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADNSSRWL, 25145, 57, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADNSSRWL")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADPST3S, 52105, 56, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODEQUADPST3S")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODESLT, 33044, 50, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBENODESLT")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBESENSE, 4113, 48, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBESENSE")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBESTAR, 38379, 47, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBESTAR")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEWHEEL, 2988, 48, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPECUBEWHEEL")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPEINVALID, 38559, 46, "COMMONFRAMEWORKTYPES1_NODETYPE_NODETYPEINVALID")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEBOOTLOADER, 26953, 55, "COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEBOOTLOADER")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPECONTROL, 48169, 52, "COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPECONTROL")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEHEALTHCHECK, 63412, 56, "COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEHEALTHCHECK")
QDEF(MP_QSTR_COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEINVALID, 60863, 52, "COMMONFRAMEWORKTYPES1_PROGRAMTYPE_PROGRAMTYPEINVALID")
QDEF(MP_QSTR_COMM_GW_RES_ERR, 2471, 15, "COMM_GW_RES_ERR")
QDEF(MP_QSTR_COMM_GW_RES_INVALID_ARGS, 11403, 24, "COMM_GW_RES_INVALID_ARGS")
QDEF(MP_QSTR_COMM_GW_RES_OK, 8070, 14, "COMM_GW_RES_OK")
QDEF(MP_QSTR_COMM_GW_RES_OK_PARTIAL, 62250, 22, "COMM_GW_RES_OK_PARTIAL")
QDEF(MP_QSTR_COMM_GW_RES_RCV_TIMEOUT, 32577, 23, "COMM_GW_RES_RCV_TIMEOUT")
QDEF(MP_QSTR_COMM_GW_RES_SEND_ERR, 46564, 20, "COMM_GW_RES_SEND_ERR")
QDEF(MP_QSTR_COMM_GW_RES_SND_TIMEOUT, 11135, 23, "COMM_GW_RES_SND_TIMEOUT")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_1_AXIS_BDOT, 250, 30, "CONTROLMODES_CNTRL_1_AXIS_BDOT")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_3_AXIS_BDOT, 26872, 30, "CONTROLMODES_CNTRL_3_AXIS_BDOT")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_3_AXIS_LOW_POWER, 64049, 35, "CONTROLMODES_CNTRL_3_AXIS_LOW_POWER")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_FMC_TARGET, 59347, 29, "CONTROLMODES_CNTRL_FMC_TARGET")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_INITIAL_Y_WHEEL_PITCH_CNTRL, 42656, 46, "CONTROLMODES_CNTRL_INITIAL_Y_WHEEL_PITCH_CNTRL")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_INITIAL_Y_WHEEL_RAMP_UP, 17930, 42, "CONTROLMODES_CNTRL_INITIAL_Y_WHEEL_RAMP_UP")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_MAG_CNTRL_GG_BOOM_AND_YAW, 44525, 44, "CONTROLMODES_CNTRL_MAG_CNTRL_GG_BOOM_AND_YAW")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_MAG_CNTRL_GG_BOOM_AND_Z, 33496, 42, "CONTROLMODES_CNTRL_MAG_CNTRL_GG_BOOM_AND_Z")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_NADIR_AND_YAW_BEST_TO_GS, 28657, 43, "CONTROLMODES_CNTRL_NADIR_AND_YAW_BEST_TO_GS")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_NADIR_AND_YAW_TO_GROUND_TARGET, 7057, 49, "CONTROLMODES_CNTRL_NADIR_AND_YAW_TO_GROUND_TARGET")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_NADIR_AND_YAW_TO_SUN, 8626, 39, "CONTROLMODES_CNTRL_NADIR_AND_YAW_TO_SUN")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_NO_CONTROL, 684, 29, "CONTROLMODES_CNTRL_NO_CONTROL")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_OPEN_LOOP_RW, 39192, 31, "CONTROLMODES_CNTRL_OPEN_LOOP_RW")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_3_AXIS, 54336, 28, "CONTROLMODES_CNTRL_RW_3_AXIS")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_EARTH_TARGET_STEERING, 32481, 43, "CONTROLMODES_CNTRL_RW_EARTH_TARGET_STEERING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_EO_TARGET_TRACKING, 21787, 40, "CONTROLMODES_CNTRL_RW_EO_TARGET_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_GS_TARGET_TRACKING, 1861, 40, "CONTROLMODES_CNTRL_RW_GS_TARGET_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_INERTIAL_TARGET_TRACKING, 32785, 46, "CONTROLMODES_CNTRL_RW_INERTIAL_TARGET_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_MOON_TRACKING, 65308, 35, "CONTROLMODES_CNTRL_RW_MOON_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_SAT_TARGET_TRACKING, 6071, 41, "CONTROLMODES_CNTRL_RW_SAT_TARGET_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_RW_SUN_TRACKING, 46647, 34, "CONTROLMODES_CNTRL_RW_SUN_TRACKING")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_STOP_RW_CONTROLLED, 36994, 37, "CONTROLMODES_CNTRL_STOP_RW_CONTROLLED")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_SUN_DETUMBLE, 64964, 31, "CONTROLMODES_CNTRL_SUN_DETUMBLE")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_SUN_Y_AXIS_SPIN_DETUMB, 14284, 41, "CONTROLMODES_CNTRL_SUN_Y_AXIS_SPIN_DETUMB")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_SUN_Z_AXIS_SPIN_DETUMB, 32495, 41, "CONTROLMODES_CNTRL_SUN_Z_AXIS_SPIN_DETUMB")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_USER, 2948, 23, "CONTROLMODES_CNTRL_USER")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_VELOCITY_AND_ROLL_TO_GROUND_TARGET, 5732, 53, "CONTROLMODES_CNTRL_VELOCITY_AND_ROLL_TO_GROUND_TARGET")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_VELOCITY_AND_ROLL_TO_SUN, 21255, 43, "CONTROLMODES_CNTRL_VELOCITY_AND_ROLL_TO_SUN")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_YAW_SUN_SPIN, 32182, 31, "CONTROLMODES_CNTRL_YAW_SUN_SPIN")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_Y_THOMSON, 55647, 28, "CONTROLMODES_CNTRL_Y_THOMSON")
QDEF(MP_QSTR_CONTROLMODES_CNTRL_Z_THOMSON, 32668, 28, "CONTROLMODES_CNTRL_Z_THOMSON")
QDEF(MP_QSTR_CP_CMD_ID_CUBEADCS_GEN2_GWSEND, 152, 30, "CP_CMD_ID_CUBEADCS_GEN2_GWSEND")
QDEF(MP_QSTR_CP_CMD_ID_CUBEADCS_GWSEND, 25849, 25, "CP_CMD_ID_CUBEADCS_GWSEND")
QDEF(MP_QSTR_CP_CMD_ID_FAULT_READ_ALL, 11575, 24, "CP_CMD_ID_FAULT_READ_ALL")
QDEF(MP_QSTR_CP_CMD_ID_SXBAND_GWSEND, 15807, 23, "CP_CMD_ID_SXBAND_GWSEND")
QDEF(MP_QSTR_CP_CMD_ID_SXBAND_SCHED_POLL, 30154, 27, "CP_CMD_ID_SXBAND_SCHED_POLL")
QDEF(MP_QSTR_CP_CMD_ID_SXBAND_SCHED_RUN, 54556, 26, "CP_CMD_ID_SXBAND_SCHED_RUN")
QDEF(MP_QSTR_CSP_LOCAL_ADDR, 19643, 14, "CSP_LOCAL_ADDR")
QDEF(MP_QSTR_CSP_O_CRC32, 25017, 11, "CSP_O_CRC32")
QDEF(MP_QSTR_CSP_O_HMAC, 53165, 10, "CSP_O_HMAC")
QDEF(MP_QSTR_CSP_O_NOCRC32, 35608, 13, "CSP_O_NOCRC32")
QDEF(MP_QSTR_CSP_O_NOHMAC, 61996, 12, "CSP_O_NOHMAC")
QDEF(MP_QSTR_CSP_O_NONE, 65472, 10, "CSP_O_NONE")
QDEF(MP_QSTR_CSP_O_NORDP, 19885, 11, "CSP_O_NORDP")
QDEF(MP_QSTR_CSP_O_NOXTEA, 21923, 12, "CSP_O_NOXTEA")
QDEF(MP_QSTR_CSP_O_RDP, 63244, 9, "CSP_O_RDP")
QDEF(MP_QSTR_CSP_O_XTEA, 11042, 10, "CSP_O_XTEA")
QDEF(MP_QSTR_CSP_PRIO_CRITICAL, 62602, 17, "CSP_PRIO_CRITICAL")
QDEF(MP_QSTR_CSP_PRIO_HIGH, 32239, 13, "CSP_PRIO_HIGH")
QDEF(MP_QSTR_CSP_PRIO_LOW, 62741, 12, "CSP_PRIO_LOW")
QDEF(MP_QSTR_CSP_PRIO_NORMAL, 6834, 15, "CSP_PRIO_NORMAL")
QDEF(MP_QSTR_CSP_SO_CONN_LESS, 19363, 16, "CSP_SO_CONN_LESS")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASEEVENTLOG, 13780, 51, "CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASEEVENTLOG")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASEIMAGELOG, 15487, 51, "CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASEIMAGELOG")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASETLMLOG, 29357, 49, "CUBECOMPUTERCOMMON3_ERASEMAGICNUMBERS_ERASETLMLOG")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSCRITICAL, 15750, 49, "CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSCRITICAL")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSINFO, 46499, 45, "CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSINFO")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSWARNINGMAJOR, 40252, 53, "CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSWARNINGMAJOR")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSWARNINGMINOR, 35888, 53, "CUBECOMPUTERCOMMON3_EVENTCLASS_EVENTCLASSWARNINGMINOR")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQDOWNLOAD, 53317, 56, "CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQDOWNLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQERASE, 39377, 53, "CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQERASE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQIDLE, 9077, 52, "CUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_EVTREADQIDLE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_CAPTUREDOWNLOAD, 61987, 55, "CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_CAPTUREDOWNLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_CAPTURESTORE, 51400, 52, "CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_CAPTURESTORE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_DOWNLOAD, 57191, 48, "CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_DOWNLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_INFORESET, 63080, 49, "CUBECOMPUTERCOMMON3_IMAGETRANSFEROPCODE_INFORESET")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEBUSYDOWNLOAD, 49256, 56, "CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEBUSYDOWNLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEBUSYSTORE, 48419, 53, "CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEBUSYSTORE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEIDLE, 51237, 48, "CUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_STATEIDLE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERCOUNTERNEXTX, 56808, 56, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERCOUNTERNEXTX")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERFIRSTX, 15425, 50, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERFIRSTX")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERLASTX, 465, 49, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERLASTX")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERNONE, 24841, 48, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERNONE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERTIMENEXTX, 33161, 53, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERTIMENEXTX")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERTIMESPAN, 45498, 52, "CUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_FILTERTIMESPAN")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWERAUTO, 32778, 41, "CUBECOMPUTERCOMMON3_POWERSELECT_POWERAUTO")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWERNOCHANGE, 15234, 45, "CUBECOMPUTERCOMMON3_POWERSELECT_POWERNOCHANGE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWEROFF, 5066, 40, "CUBECOMPUTERCOMMON3_POWERSELECT_POWEROFF")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWEROFFUPGRADE, 48922, 47, "CUBECOMPUTERCOMMON3_POWERSELECT_POWEROFFUPGRADE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWERON, 53764, 39, "CUBECOMPUTERCOMMON3_POWERSELECT_POWERON")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_POWERSELECT_POWERONPASS, 3317, 43, "CUBECOMPUTERCOMMON3_POWERSELECT_POWERONPASS")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQDOWNLOAD, 22954, 57, "CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQDOWNLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQERASE, 45214, 54, "CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQERASE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQIDLE, 40218, 53, "CUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TLMREADQIDLE")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL100S, 4908, 59, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL100S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL10S, 8188, 58, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL10S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL1S, 26028, 57, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL1S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL200MS, 22690, 60, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL200MS")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL20S, 7039, 58, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL20S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL2S, 26063, 57, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL2S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL3S, 26094, 57, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL3S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL4S, 25865, 57, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL4S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL50S, 3832, 58, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL50S")
QDEF(MP_QSTR_CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL5S, 25896, 57, "CUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_INTERVAL5S")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSCONTROLLER, 12842, 69, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSCONTROLLER")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSESTIMATION, 20941, 69, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSESTIMATION")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSMODELS, 56522, 65, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTADCSMODELS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTHOUSEKEEPING, 38300, 67, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTHOUSEKEEPING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTIDLE, 33031, 59, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTIDLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTINIT, 27065, 59, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTINIT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTSENSORCOMMS, 7562, 66, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTSENSORCOMMS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTTLMLOG, 6578, 61, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTTLMLOG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTWHEELCOMMS, 18671, 65, "CUBECOMPUTERCONTROLPROGRAM8_ACPEXECUTIONPOINT_EXECPOINTWHEELCOMMS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEAUTO, 41066, 57, "CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEAUTO")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEFAULT, 25551, 58, "CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEFAULT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEMANUAL, 19551, 59, "CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATEMANUAL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATESAFE, 28020, 57, "CUBECOMPUTERCONTROLPROGRAM8_ADCSOPSTATESELECT_OPSTATESAFE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSENABLED, 19103, 57, "CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSENABLED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSOFF, 48437, 53, "CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSSIMULATION, 57673, 60, "CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSSIMULATION")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSTRIGGERED, 42243, 59, "CUBECOMPUTERCONTROLPROGRAM8_ADCSRUNMODESELECT_ADCSTRIGGERED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_AAMMODE, 57716, 53, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_AAMMODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_ARMMODE, 24327, 53, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_ARMMODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_ATMMODE, 41025, 53, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_ATMMODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_INITIALIZATION, 16938, 60, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_INITIALIZATION")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_PHOTOMODE, 35413, 55, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_PHOTOMODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_SELFTEST, 20144, 54, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_SELFTEST")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_STANDBY, 55597, 53, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_STANDBY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_TRACKING, 44341, 54, "CUBECOMPUTERCONTROLPROGRAM8_AURIGALIBSTATEVAL_TRACKING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGX, 36548, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGX")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGY, 36549, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGZ, 36550, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNEGZ")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNOTUSED, 34178, 50, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISNOTUSED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDA, 15976, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDA")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDB, 15979, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDB")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDC, 15978, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDC")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDD, 15981, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPMDD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSX, 22788, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSX")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSY, 22789, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSZ, 22790, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISPOSZ")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISSKEW, 53946, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISSKEW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDA, 27305, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDA")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDB, 27306, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDB")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDC, 27307, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDC")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDD, 27308, 47, "CUBECOMPUTERCONTROLPROGRAM8_AXISSELECT_AXISTHDD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONASTROSTEER, 35901, 55, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONASTROSTEER")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONBDOT, 11758, 49, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONBDOT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONBDOT3, 60317, 50, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONBDOT3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONDETUMBLE, 32885, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONDETUMBLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONFMCTARGET, 63850, 54, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONFMCTARGET")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGGBOOM, 2908, 51, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGGBOOM")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGGSUN, 9531, 50, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGGSUN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGNDTRACK, 37393, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONGNDTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONHXYZRW, 10021, 51, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONHXYZRW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONIRCTRACK, 13284, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONIRCTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONMOONTRACK, 15615, 54, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONMOONTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONNONE, 29401, 49, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONROLLSUN, 32038, 52, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONROLLSUN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONROLLTARGET, 51775, 55, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONROLLTARGET")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSATTRACK, 666, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSATTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSTOPRW, 22734, 51, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSTOPRW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNDETUMBLE, 10173, 56, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNDETUMBLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNPAYLOAD, 22773, 55, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNPAYLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNTRACK, 32084, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNYSPIN, 48230, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNYSPIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNZSPIN, 52581, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONSUNZSPIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONTGTSTEER, 33057, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONTGTSTEER")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONTGTTRACK, 59259, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONTGTTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONUSER, 17090, 49, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONUSER")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONXYZWHEEL, 52987, 53, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONXYZWHEEL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWSUN, 25652, 51, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWSUN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWSUNSPIN, 33200, 55, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWSUNSPIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWTARGET, 52205, 54, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWTARGET")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWTARGETBEST, 12493, 58, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYAWTARGETBEST")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYSPIN, 52910, 50, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYSPIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYWHEEL, 31001, 51, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYWHEEL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYWHEELINIT, 43203, 55, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONYWHEELINIT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONZSPIN, 48813, 50, "CUBECOMPUTERCONTROLPROGRAM8_CONMODESELECT_CONZSPIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRX, 58942, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRX")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRY, 58943, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRZ, 58940, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNGYRZ")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNNONE, 2240, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL0, 47987, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL1, 47986, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL2, 47985, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL3, 47984, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNRWL3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNSTR0, 16015, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNSTR0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNSTR1, 16014, 47, "CUBECOMPUTERCONTROLPROGRAM8_CQASSIGN_ASSIGNSTR1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPERROR, 15647, 60, "CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPERROR")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPPENDING, 35480, 62, "CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPSTARTUP, 57730, 62, "CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPSUCCESS, 28484, 62, "CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPSUCCESS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPTIMEOUT, 48092, 62, "CUBECOMPUTERCONTROLPROGRAM8_EARTHCAPTURERESULT_EARTHCAPTIMEOUT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHBADFIT, 30922, 57, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHBADFIT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHDETPENDING, 27932, 61, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHDETPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHDETSTARTUP, 1286, 61, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHDETSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHNOHORIZON, 29168, 60, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHNOHORIZON")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHSUCCESS, 64533, 58, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHSUCCESS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHTOOFEWEDGES, 38022, 62, "CUBECOMPUTERCONTROLPROGRAM8_EARTHDETECTRESULT_EARTHTOOFEWEDGES")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTFULLEKF, 8872, 52, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTFULLEKF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTGYRO, 9584, 49, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTGYRO")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTGYROEKF, 27928, 52, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTGYROEKF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTMAGRKF, 32871, 51, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTMAGRKF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTNONE, 53721, 49, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTPITCHRKF, 26346, 53, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTPITCHRKF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTTRIAD, 52185, 50, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTTRIAD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTUSER, 41410, 49, "CUBECOMPUTERCONTROLPROGRAM8_ESTMODESELECT_ESTUSER")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC2, 12007, 42, "CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC4, 12001, 42, "CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC4")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC8, 12013, 42, "CUBECOMPUTERCONTROLPROGRAM8_FMCFACTOR_FMC8")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCENDED, 53842, 45, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCENDED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCINACTIVE, 17079, 48, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCINACTIVE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCINITIALPITCH, 6468, 52, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCINITIALPITCH")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCPREPARE, 47485, 47, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCPREPARE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCRWRAMPDOWN, 30053, 50, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCRWRAMPDOWN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCRWRAMPUP, 63090, 48, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCRWRAMPUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCSCAN, 34915, 44, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCSCAN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCSTOPPING, 46004, 48, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCSTOPPING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCWAITING, 9047, 47, "CUBECOMPUTERCONTROLPROGRAM8_FMCSTAGE_FMCWAITING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPBACKEND_BACKENDFRAM, 49634, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPBACKEND_BACKENDFRAM")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPBACKEND_BACKENDNODE, 47130, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPBACKEND_BACKENDNODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBL52BIN, 36534, 48, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBL52BIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBLCCBIN, 50001, 48, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBLCCBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBLR5SBBIN, 52135, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_BASEBLR5SBBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGABIN, 43218, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGABIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGACFG0, 12965, 51, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGACFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGACFG1, 12964, 51, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEAURIGACFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRBIN, 14944, 46, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRCFG0, 46295, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRCFG1, 46294, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEIRCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTBIN, 57399, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTCFG0, 26144, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTCFG1, 26145, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGCOMPACTCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYBIN, 9147, 53, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYCFG0, 15404, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYCFG1, 15405, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEMAGDEPLOYCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLBIN, 38108, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG0, 45291, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG1, 45290, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG2, 45289, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG3, 45288, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODENSSRWLCFG3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SBIN, 39404, 53, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SCFG0, 26587, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SCFG1, 26586, 54, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEPST3SCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSBIN, 24949, 62, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSCFG0, 65314, 63, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSCFG1, 65315, 63, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADLITEFUFORSCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADNSSRWLBIN, 28605, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADNSSRWLBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADNSSRWLCFG0, 6250, 59, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADNSSRWLCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADPST3SBIN, 60589, 57, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADPST3SBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADPST3SCFG0, 13178, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODEQUADPST3SCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODESLTBIN, 40592, 51, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODESLTBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODESLTCFG0, 53287, 52, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBENODESLTCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSEBIN, 1205, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSEBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG0, 2658, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG1, 2659, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG2, 2656, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG3, 2657, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESENSECFG3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARBIN, 33135, 48, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG0, 28792, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG1, 28793, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG2, 28794, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG3, 28795, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBESTARCFG3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELBIN, 56360, 49, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG0, 62111, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG1, 62110, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG2, 62109, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG3, 62108, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG4, 62107, 50, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_CUBEWHEELCFG4")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_FILEINVALID, 44248, 48, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILES_FILEINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_BIN, 30401, 43, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_BIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_CFG, 35110, 43, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_CFG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_GENERAL, 6034, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_GENERAL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_LOG, 36352, 43, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_LOG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_PHOTO, 8680, 45, "CUBECOMPUTERCONTROLPROGRAM8_FTPFILETYPE_PHOTO")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPCANCEL, 32876, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPCANCEL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPERASE, 56202, 46, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPERASE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPFORMAT, 16265, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPFORMAT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPINFO, 30788, 45, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPINFO")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPNONE, 63328, 45, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPUPGRADE, 36474, 48, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPUPGRADE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPUPLOAD, 28201, 47, "CUBECOMPUTERCONTROLPROGRAM8_FTPOPCODE_FTPUPLOAD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_BUSY, 40080, 41, "CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_BUSY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_IDLE, 31049, 41, "CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_IDLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_INIT, 45559, 41, "CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_INIT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_LOCKED, 7399, 43, "CUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_LOCKED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEBUSYBIN, 34997, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEBUSYBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEBUSYCFG, 35858, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEBUSYCFG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEIDLE, 50313, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEIDLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINIT, 56375, 55, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINIT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINITBIN, 34162, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINITBIN")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINITCFG, 32661, 58, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADEINITCFG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADETRANS, 46359, 56, "CUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_UPGRADETRANS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITDONE, 28239, 46, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITDONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITJUMP, 33133, 46, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITJUMP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITMAX, 49051, 45, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITMAX")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITOFF, 42784, 45, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITPASS, 27646, 46, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITPASS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITSETUP, 40360, 47, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITSETUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITUPGRADE, 23935, 49, "CUBECOMPUTERCONTROLPROGRAM8_INITSTATE_INITUPGRADE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_MAGSENSINGELEMENTSELECT_MAGPRIMARY, 20329, 62, "CUBECOMPUTERCONTROLPROGRAM8_MAGSENSINGELEMENTSELECT_MAGPRIMARY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_MAGSENSINGELEMENTSELECT_MAGREDUNDANT, 12370, 64, "CUBECOMPUTERCONTROLPROGRAM8_MAGSENSINGELEMENTSELECT_MAGREDUNDANT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQNEGATIVE, 48735, 51, "CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQNEGATIVE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQOFF, 13427, 46, "CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQPOSITIVE, 2711, 51, "CUBECOMPUTERCONTROLPROGRAM8_MTQPOLARITY_MTQPOSITIVE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVASGP4TLE, 14889, 49, "CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVASGP4TLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVGNSSNOW, 27066, 48, "CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVGNSSNOW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVGNSSPROPAGATED, 65347, 55, "CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVGNSSPROPAGATED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVTLE, 5752, 44, "CUBECOMPUTERCONTROLPROGRAM8_NAVSOURCE_NAVTLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTNONE, 52082, 45, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR1, 28767, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR2, 28764, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR3, 28765, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR4, 28762, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR4")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR5, 28763, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR5")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR6, 28760, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR6")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR7, 28761, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR7")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR8, 28758, 48, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTSENSOR8")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL1, 17050, 47, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL2, 17049, 47, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL3, 17048, 47, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL4, 17055, 47, "CUBECOMPUTERCONTROLPROGRAM8_NODEPORT_PORTWHEEL4")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEACQFF, 61744, 51, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEACQFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEACQHW, 61935, 51, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEACQHW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATECHECK, 42341, 51, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATECHECK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATECONFIG, 55913, 52, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATECONFIG")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEFIRSTTRACK, 25814, 56, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEFIRSTTRACK")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEINITTEMPO, 38010, 55, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEINITTEMPO")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEOFF, 14284, 49, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATESTANDBY, 39956, 53, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATESTANDBY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATETRACKING, 12332, 54, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATETRACKING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEWAITON, 33609, 52, "CUBECOMPUTERCONTROLPROGRAM8_OHSTATEVAL_OHSTATEWAITON")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBASGP4, 7906, 50, "CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBASGP4")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBASGP4GNSS, 45227, 54, "CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBASGP4GNSS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBTLE, 4206, 48, "CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBTLE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBTLEGNSS, 807, 52, "CUBECOMPUTERCONTROLPROGRAM8_ORBMODESELECT_ORBTLEGNSS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SDATAVALID_ATTITUDEVALID, 12279, 56, "CUBECOMPUTERCONTROLPROGRAM8_PST3SDATAVALID_ATTITUDEVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SDATAVALID_GESTUREVALID, 6584, 55, "CUBECOMPUTERCONTROLPROGRAM8_PST3SDATAVALID_GESTUREVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODEHIGH, 30113, 60, "CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODEHIGH")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODEINVALID, 45118, 63, "CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODEINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODELOW, 52123, 59, "CUBECOMPUTERCONTROLPROGRAM8_PST3SDYNAMICMODE_DYNAMICMODELOW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEINVALID, 1, 59, "CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEOFF, 27230, 55, "CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEON, 34576, 54, "CUBECOMPUTERCONTROLPROGRAM8_PST3SEXTIMAGESTATE_IMAGEON")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_FIXEDTHRESHOLD, 7811, 62, "CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_FIXEDTHRESHOLD")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_MODEINVALID, 27440, 59, "CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_MODEINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_NORMALMODE, 43762, 58, "CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_NORMALMODE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_SELFTEST, 56808, 56, "CUBECOMPUTERCONTROLPROGRAM8_PST3SOPERATINGMODES_SELFTEST")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETINVALID, 35640, 81, "CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETOFF, 14822, 77, "CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETON, 34216, 76, "CUBECOMPUTERCONTROLPROGRAM8_PST3SQUATERNIONFILTERINGGETSTATE_QFILTERINGGETON")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_ESTIMATED, 12210, 54, "CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_ESTIMATED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_PRECISE, 13435, 52, "CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_PRECISE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_RATEINVALID, 27379, 56, "CUBECOMPUTERCONTROLPROGRAM8_PST3SRATEQUALITY_RATEINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAALL, 2412, 54, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAALL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAACAPTURE, 12809, 58, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAACAPTURE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAINVALID, 41468, 58, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAINVALID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAOFF, 61602, 54, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAAOFF")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAATRACKING, 64194, 59, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSAAWORKINGMODE_SAATRACKING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSELFTESTRESULT_CORRECT, 2610, 55, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSELFTESTRESULT_CORRECT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SSELFTESTRESULT_ERROR, 27284, 53, "CUBECOMPUTERCONTROLPROGRAM8_PST3SSELFTESTRESULT_ERROR")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SVERSION_PST3SVERSIONG2, 39277, 55, "CUBECOMPUTERCONTROLPROGRAM8_PST3SVERSION_PST3SVERSIONG2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_PST3SVERSION_PST3SVERSIONH3, 38723, 55, "CUBECOMPUTERCONTROLPROGRAM8_PST3SVERSION_PST3SVERSIONH3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL0, 3973, 46, "CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL0")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL1, 3972, 46, "CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL1")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL2, 3975, 46, "CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL2")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL3, 3974, 46, "CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAIL3")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAILNONE, 11615, 49, "CUBECOMPUTERCONTROLPROGRAM8_RWLFAILID_RWLFAILNONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMENOWHEELS, 19705, 55, "CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMENOWHEELS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEPYRAMID, 60994, 54, "CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEPYRAMID")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMETETRAHEDRAL, 42104, 58, "CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMETETRAHEDRAL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEXYZ, 31491, 50, "CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEXYZ")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEYMOMENTUM, 55369, 56, "CUBECOMPUTERCONTROLPROGRAM8_RWLSCHEME_RWLSCHEMEYMOMENTUM")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREBUSY, 32433, 61, "CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREBUSY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREDONE, 51852, 61, "CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREDONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREERROR, 27188, 62, "CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREERROR")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREPENDING, 51571, 64, "CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTUREPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTURESTARTUP, 42601, 64, "CUBECOMPUTERCONTROLPROGRAM8_STARCAPTURESTATUS_STARCAPTURESTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTABORT, 1094, 60, "CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTABORT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTBUSY, 25585, 59, "CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTBUSY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTDONE, 4556, 59, "CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTDONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTPENDING, 30771, 62, "CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTSTARTUP, 62505, 62, "CUBECOMPUTERCONTROLPROGRAM8_STARDETECTSTATUS_STARDETECTSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDABORT, 54662, 52, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDABORT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDBUSY, 16049, 51, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDBUSY")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDDONE, 35468, 51, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDDONE")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDOUTOFMEM, 49422, 55, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDOUTOFMEM")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDPENDING, 35187, 54, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDSTARTUP, 26217, 54, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDTOOFEW, 36876, 53, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDTOOFEW")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDTRACKERR, 48582, 55, "CUBECOMPUTERCONTROLPROGRAM8_STARIDSTATUS_STARIDTRACKERR")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPPENDING, 39640, 58, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPSTARTUP, 20674, 58, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPTURESUCCESSFLIPPED, 32560, 69, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPTURESUCCESSFLIPPED")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPTURESUCCESSNORMAL, 44961, 68, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNCAPTURESUCCESSNORMAL")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNSRAMERR, 20701, 55, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNSRAMERR")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNTIMEOUT, 36302, 55, "CUBECOMPUTERCONTROLPROGRAM8_SUNCAPTURERESULT_SUNTIMEOUT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNDETPENDING, 6876, 57, "CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNDETPENDING")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNDETSTARTUP, 4550, 57, "CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNDETSTARTUP")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNNODETECT, 5328, 55, "CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNNODETECT")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNNOTFOUND, 31445, 55, "CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNNOTFOUND")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNSUCCESS, 41557, 54, "CUBECOMPUTERCONTROLPROGRAM8_SUNDETECTRESULT_SUNSUCCESS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECCSS, 9235, 44, "CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECCSS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECFSS, 8342, 44, "CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECFSS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECHSS, 14872, 44, "CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECHSS")
QDEF(MP_QSTR_CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECMAG, 16603, 44, "CUBECOMPUTERCONTROLPROGRAM8_VECSELECT_VECMAG")
QDEF(MP_QSTR_CmdTargetNode, 52734, 13, "CmdTargetNode")
QDEF(MP_QSTR_CommissioningStatus, 46716, 19, "CommissioningStatus")
QDEF(MP_QSTR_CommonFrameworkTypes1_AbstractNode, 53681, 34, "CommonFrameworkTypes1_AbstractNode")
QDEF(MP_QSTR_CommonFrameworkTypes1_NodeType, 29257, 30, "CommonFrameworkTypes1_NodeType")
QDEF(MP_QSTR_CommonFrameworkTypes1_ProgramType, 59677, 33, "CommonFrameworkTypes1_ProgramType")
QDEF(MP_QSTR_CompErrCodes, 48399, 12, "CompErrCodes")
QDEF(MP_QSTR_CompErrCodes_make_from_buf, 4469, 26, "CompErrCodes_make_from_buf")
QDEF(MP_QSTR_ComponentErrorCodes, 59500, 19, "ComponentErrorCodes")
QDEF(MP_QSTR_ComponentErrorCodes_make_from_buf, 14486, 33, "ComponentErrorCodes_make_from_buf")
QDEF(MP_QSTR_ConMode, 6532, 7, "ConMode")
QDEF(MP_QSTR_ConMode_make_from_buf, 47486, 21, "ConMode_make_from_buf")
QDEF(MP_QSTR_ConfigActuatorMtq, 12652, 17, "ConfigActuatorMtq")
QDEF(MP_QSTR_ConfigActuatorMtq_make_from_buf, 16790, 31, "ConfigActuatorMtq_make_from_buf")
QDEF(MP_QSTR_ConfigActuatorRwl, 23181, 17, "ConfigActuatorRwl")
QDEF(MP_QSTR_ConfigActuatorRwl_make_from_buf, 30711, 31, "ConfigActuatorRwl_make_from_buf")
QDEF(MP_QSTR_ConfigAdcsController, 5990, 20, "ConfigAdcsController")
QDEF(MP_QSTR_ConfigAdcsController_make_from_buf, 8348, 34, "ConfigAdcsController_make_from_buf")
QDEF(MP_QSTR_ConfigAdcsEstimator, 57620, 19, "ConfigAdcsEstimator")
QDEF(MP_QSTR_ConfigAdcsEstimator_make_from_buf, 22766, 33, "ConfigAdcsEstimator_make_from_buf")
QDEF(MP_QSTR_ConfigAdcsSatellite, 18177, 19, "ConfigAdcsSatellite")
QDEF(MP_QSTR_ConfigAdcsSatellite_make_from_buf, 29563, 33, "ConfigAdcsSatellite_make_from_buf")
QDEF(MP_QSTR_ConfigAsgp4, 20030, 11, "ConfigAsgp4")
QDEF(MP_QSTR_ConfigAsgp4_make_from_buf, 44356, 25, "ConfigAsgp4_make_from_buf")
QDEF(MP_QSTR_ConfigDefaultModes, 13908, 18, "ConfigDefaultModes")
QDEF(MP_QSTR_ConfigDefaultModes_make_from_buf, 60462, 32, "ConfigDefaultModes_make_from_buf")
QDEF(MP_QSTR_ConfigMag0OrbitCal, 57432, 18, "ConfigMag0OrbitCal")
QDEF(MP_QSTR_ConfigMag0OrbitCal_make_from_buf, 1314, 32, "ConfigMag0OrbitCal_make_from_buf")
QDEF(MP_QSTR_ConfigMag1OrbitCal, 59417, 18, "ConfigMag1OrbitCal")
QDEF(MP_QSTR_ConfigMag1OrbitCal_make_from_buf, 60515, 32, "ConfigMag1OrbitCal_make_from_buf")
QDEF(MP_QSTR_ConfigMagSensingElement, 10353, 23, "ConfigMagSensingElement")
QDEF(MP_QSTR_ConfigMagSensingElement_make_from_buf, 64011, 37, "ConfigMagSensingElement_make_from_buf")
QDEF(MP_QSTR_ConfigMount, 8994, 11, "ConfigMount")
QDEF(MP_QSTR_ConfigMount_make_from_buf, 47448, 25, "ConfigMount_make_from_buf")
QDEF(MP_QSTR_ConfigNodeSelection, 29519, 19, "ConfigNodeSelection")
QDEF(MP_QSTR_ConfigNodeSelection_make_from_buf, 26549, 33, "ConfigNodeSelection_make_from_buf")
QDEF(MP_QSTR_ConfigOrbitSatParams, 55223, 20, "ConfigOrbitSatParams")
QDEF(MP_QSTR_ConfigOrbitSatParams_make_from_buf, 5197, 34, "ConfigOrbitSatParams_make_from_buf")
QDEF(MP_QSTR_ConfigOrbitTargetParams, 43744, 23, "ConfigOrbitTargetParams")
QDEF(MP_QSTR_ConfigOrbitTargetParams_make_from_buf, 35354, 37, "ConfigOrbitTargetParams_make_from_buf")
QDEF(MP_QSTR_ControlMode, 7969, 11, "ControlMode")
QDEF(MP_QSTR_ControlModeConfig, 55179, 17, "ControlModeConfig")
QDEF(MP_QSTR_ControlModeConfig_make_from_buf, 6897, 31, "ControlModeConfig_make_from_buf")
QDEF(MP_QSTR_ControlMode_make_from_buf, 63963, 25, "ControlMode_make_from_buf")
QDEF(MP_QSTR_ControlModes, 818, 12, "ControlModes")
QDEF(MP_QSTR_CubeComputerCommon3_EraseMagicNumbers, 12675, 37, "CubeComputerCommon3_EraseMagicNumbers")
QDEF(MP_QSTR_CubeComputerCommon3_EventClass, 46544, 30, "CubeComputerCommon3_EventClass")
QDEF(MP_QSTR_CubeComputerCommon3_EventReadQueueState, 44746, 39, "CubeComputerCommon3_EventReadQueueState")
QDEF(MP_QSTR_CubeComputerCommon3_ImageTransferOpCode, 20396, 39, "CubeComputerCommon3_ImageTransferOpCode")
QDEF(MP_QSTR_CubeComputerCommon3_ImageTransferState, 30761, 38, "CubeComputerCommon3_ImageTransferState")
QDEF(MP_QSTR_CubeComputerCommon3_LogReadFilterType, 52860, 37, "CubeComputerCommon3_LogReadFilterType")
QDEF(MP_QSTR_CubeComputerCommon3_PowerSelect, 43461, 31, "CubeComputerCommon3_PowerSelect")
QDEF(MP_QSTR_CubeComputerCommon3_TlmLogReadQueueState, 5207, 40, "CubeComputerCommon3_TlmLogReadQueueState")
QDEF(MP_QSTR_CubeComputerCommon3_TlmLogReturnIntervalValues, 3758, 46, "CubeComputerCommon3_TlmLogReturnIntervalValues")
QDEF(MP_QSTR_CubeComputerControlProgram8_AcpExecutionPoint, 51403, 45, "CubeComputerControlProgram8_AcpExecutionPoint")
QDEF(MP_QSTR_CubeComputerControlProgram8_AdcsOpStateSelect, 21074, 45, "CubeComputerControlProgram8_AdcsOpStateSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_AdcsRunModeSelect, 28368, 45, "CubeComputerControlProgram8_AdcsRunModeSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_AurigaLibStateVal, 41509, 45, "CubeComputerControlProgram8_AurigaLibStateVal")
QDEF(MP_QSTR_CubeComputerControlProgram8_AxisSelect, 10668, 38, "CubeComputerControlProgram8_AxisSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_ConModeSelect, 13390, 41, "CubeComputerControlProgram8_ConModeSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_CqAssign, 20340, 36, "CubeComputerControlProgram8_CqAssign")
QDEF(MP_QSTR_CubeComputerControlProgram8_EarthCaptureResult, 23520, 46, "CubeComputerControlProgram8_EarthCaptureResult")
QDEF(MP_QSTR_CubeComputerControlProgram8_EarthDetectResult, 27235, 45, "CubeComputerControlProgram8_EarthDetectResult")
QDEF(MP_QSTR_CubeComputerControlProgram8_EstModeSelect, 7246, 41, "CubeComputerControlProgram8_EstModeSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_FmcFactor, 53122, 37, "CubeComputerControlProgram8_FmcFactor")
QDEF(MP_QSTR_CubeComputerControlProgram8_FmcStage, 60715, 36, "CubeComputerControlProgram8_FmcStage")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpBackend, 19361, 38, "CubeComputerControlProgram8_FtpBackend")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpFileType, 47451, 39, "CubeComputerControlProgram8_FtpFileType")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpFiles, 5232, 36, "CubeComputerControlProgram8_FtpFiles")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpOpCode, 64023, 37, "CubeComputerControlProgram8_FtpOpCode")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpState, 30962, 36, "CubeComputerControlProgram8_FtpState")
QDEF(MP_QSTR_CubeComputerControlProgram8_FtpUpgradeState, 36610, 43, "CubeComputerControlProgram8_FtpUpgradeState")
QDEF(MP_QSTR_CubeComputerControlProgram8_InitState, 29674, 37, "CubeComputerControlProgram8_InitState")
QDEF(MP_QSTR_CubeComputerControlProgram8_MagSensingElementSelect, 849, 51, "CubeComputerControlProgram8_MagSensingElementSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_MtqPolarity, 55979, 39, "CubeComputerControlProgram8_MtqPolarity")
QDEF(MP_QSTR_CubeComputerControlProgram8_NavSource, 55779, 37, "CubeComputerControlProgram8_NavSource")
QDEF(MP_QSTR_CubeComputerControlProgram8_NodePort, 510, 36, "CubeComputerControlProgram8_NodePort")
QDEF(MP_QSTR_CubeComputerControlProgram8_OhStateVal, 14572, 38, "CubeComputerControlProgram8_OhStateVal")
QDEF(MP_QSTR_CubeComputerControlProgram8_OrbModeSelect, 7091, 41, "CubeComputerControlProgram8_OrbModeSelect")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sDataValid, 36406, 42, "CubeComputerControlProgram8_Pst3sDataValid")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sDynamicMode, 57446, 44, "CubeComputerControlProgram8_Pst3sDynamicMode")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sExtImageState, 10217, 46, "CubeComputerControlProgram8_Pst3sExtImageState")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sOperatingModes, 40637, 47, "CubeComputerControlProgram8_Pst3sOperatingModes")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sQuaternionFilteringGetState, 1137, 60, "CubeComputerControlProgram8_Pst3sQuaternionFilteringGetState")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sRateQuality, 16735, 44, "CubeComputerControlProgram8_Pst3sRateQuality")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sSaaWorkingMode, 26241, 47, "CubeComputerControlProgram8_Pst3sSaaWorkingMode")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sSelfTestResult, 55763, 47, "CubeComputerControlProgram8_Pst3sSelfTestResult")
QDEF(MP_QSTR_CubeComputerControlProgram8_Pst3sVersion, 43050, 40, "CubeComputerControlProgram8_Pst3sVersion")
QDEF(MP_QSTR_CubeComputerControlProgram8_RwlFailId, 37985, 37, "CubeComputerControlProgram8_RwlFailId")
QDEF(MP_QSTR_CubeComputerControlProgram8_RwlScheme, 44187, 37, "CubeComputerControlProgram8_RwlScheme")
QDEF(MP_QSTR_CubeComputerControlProgram8_StarCaptureStatus, 9667, 45, "CubeComputerControlProgram8_StarCaptureStatus")
QDEF(MP_QSTR_CubeComputerControlProgram8_StarDetectStatus, 39360, 44, "CubeComputerControlProgram8_StarDetectStatus")
QDEF(MP_QSTR_CubeComputerControlProgram8_StarIdStatus, 65290, 40, "CubeComputerControlProgram8_StarIdStatus")
QDEF(MP_QSTR_CubeComputerControlProgram8_SunCaptureResult, 14626, 44, "CubeComputerControlProgram8_SunCaptureResult")
QDEF(MP_QSTR_CubeComputerControlProgram8_SunDetectResult, 42977, 43, "CubeComputerControlProgram8_SunDetectResult")
QDEF(MP_QSTR_CubeComputerControlProgram8_VecSelect, 26335, 37, "CubeComputerControlProgram8_VecSelect")
QDEF(MP_QSTR_CubeNodePortMap, 42961, 15, "CubeNodePortMap")
QDEF(MP_QSTR_CubeNodePortMap_make_from_buf, 26923, 29, "CubeNodePortMap_make_from_buf")
QDEF(MP_QSTR_DeployCommandMag, 6018, 16, "DeployCommandMag")
QDEF(MP_QSTR_DeployCommandMag_make_from_buf, 40312, 30, "DeployCommandMag_make_from_buf")
QDEF(MP_QSTR_DummyEvent, 51841, 10, "DummyEvent")
QDEF(MP_QSTR_DummyEvent_make_from_buf, 5883, 24, "DummyEvent_make_from_buf")
QDEF(MP_QSTR_ESPS_SYS_BUS_ID, 19199, 15, "ESPS_SYS_BUS_ID")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_FULL_STATE_EKF, 48032, 34, "ESTIMATIONMODES_EST_FULL_STATE_EKF")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_GYRO_EKF, 40120, 28, "ESTIMATIONMODES_EST_GYRO_EKF")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_GYRO_MEASURED_RATES, 17954, 39, "ESTIMATIONMODES_EST_GYRO_MEASURED_RATES")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_MAG_EST_RATES, 56596, 33, "ESTIMATIONMODES_EST_MAG_EST_RATES")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_MAG_EST_RATES_WITH_PITCH_EST, 13453, 48, "ESTIMATIONMODES_EST_MAG_EST_RATES_WITH_PITCH_EST")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_NO_ESIMATOR, 27304, 31, "ESTIMATIONMODES_EST_NO_ESIMATOR")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_TRIAD, 49510, 25, "ESTIMATIONMODES_EST_TRIAD")
QDEF(MP_QSTR_ESTIMATIONMODES_EST_USER, 44573, 24, "ESTIMATIONMODES_EST_USER")
QDEF(MP_QSTR_EVENTS_ENTER_IDLE, 33942, 17, "EVENTS_ENTER_IDLE")
QDEF(MP_QSTR_EVENTS_ENTER_MISSION, 30366, 20, "EVENTS_ENTER_MISSION")
QDEF(MP_QSTR_EVENTS_ENTER_SAFE, 4035, 17, "EVENTS_ENTER_SAFE")
QDEF(MP_QSTR_EVENTS_ENUM_ADCS_CONFIG_VALIDATION_ERROR, 12506, 40, "EVENTS_ENUM_ADCS_CONFIG_VALIDATION_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_AUTO_DISCOVERY_ERROR, 8980, 32, "EVENTS_ENUM_AUTO_DISCOVERY_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_CONFIG_PERSIST_ERROR, 47105, 32, "EVENTS_ENUM_CONFIG_PERSIST_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_CONTROL_LOOP_CRITICAL, 45945, 33, "EVENTS_ENUM_CONTROL_LOOP_CRITICAL")
QDEF(MP_QSTR_EVENTS_ENUM_CONTROL_LOOP_FAILURE, 48978, 32, "EVENTS_ENUM_CONTROL_LOOP_FAILURE")
QDEF(MP_QSTR_EVENTS_ENUM_GYRO_CRITICAL, 32510, 25, "EVENTS_ENUM_GYRO_CRITICAL")
QDEF(MP_QSTR_EVENTS_ENUM_GYRO_VOLTAGE_ERROR, 10256, 30, "EVENTS_ENUM_GYRO_VOLTAGE_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_MAG_DEPLOY_ERROR, 34545, 28, "EVENTS_ENUM_MAG_DEPLOY_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_NODE_COMMUNICATION_ERROR, 21489, 36, "EVENTS_ENUM_NODE_COMMUNICATION_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_NODE_FAILURE, 65366, 24, "EVENTS_ENUM_NODE_FAILURE")
QDEF(MP_QSTR_EVENTS_ENUM_NODE_JUMP_ERROR, 40723, 27, "EVENTS_ENUM_NODE_JUMP_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_NODE_SETUP_ERROR, 38198, 28, "EVENTS_ENUM_NODE_SETUP_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_PORT_VALIDATION_ERROR, 17827, 33, "EVENTS_ENUM_PORT_VALIDATION_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_VIRTUAL_WATCHDOG_ERROR, 21429, 34, "EVENTS_ENUM_VIRTUAL_WATCHDOG_ERROR")
QDEF(MP_QSTR_EVENTS_ENUM_VIRTUAL_WATCHDOG_WARNING, 25319, 36, "EVENTS_ENUM_VIRTUAL_WATCHDOG_WARNING")
QDEF(MP_QSTR_EVENTS_PERIODIC, 53770, 15, "EVENTS_PERIODIC")
QDEF(MP_QSTR_EVENTS_RESET, 28720, 12, "EVENTS_RESET")
QDEF(MP_QSTR_EraseLogData, 56369, 12, "EraseLogData")
QDEF(MP_QSTR_EraseLogData_make_from_buf, 11979, 26, "EraseLogData_make_from_buf")
QDEF(MP_QSTR_EstMode, 61828, 7, "EstMode")
QDEF(MP_QSTR_EstModeConfig, 34414, 13, "EstModeConfig")
QDEF(MP_QSTR_EstModeConfig_make_from_buf, 12180, 27, "EstModeConfig_make_from_buf")
QDEF(MP_QSTR_EstMode_make_from_buf, 37246, 21, "EstMode_make_from_buf")
QDEF(MP_QSTR_EstimationModes, 31758, 15, "EstimationModes")
QDEF(MP_QSTR_EventLogFilterTransferSetup, 35041, 27, "EventLogFilterTransferSetup")
QDEF(MP_QSTR_EventLogFilterTransferSetup_make_from_buf, 33435, 41, "EventLogFilterTransferSetup_make_from_buf")
QDEF(MP_QSTR_EventLogStatus, 62777, 14, "EventLogStatus")
QDEF(MP_QSTR_EventLogStatus_make_from_buf, 26563, 28, "EventLogStatus_make_from_buf")
QDEF(MP_QSTR_Events, 59514, 6, "Events")
QDEF(MP_QSTR_ExpectedNodes, 32296, 13, "ExpectedNodes")
QDEF(MP_QSTR_ExpectedNodes_make_from_buf, 48210, 27, "ExpectedNodes_make_from_buf")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_BLOCK_NUMBER_MISMATCH, 35558, 40, "FILESTATUS_ES_TFTP_BLOCK_NUMBER_MISMATCH")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_BUSY, 46133, 23, "FILESTATUS_ES_TFTP_BUSY")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_CANNOT_OPEN_DEST_FILE_FOR_WRITE, 36444, 50, "FILESTATUS_ES_TFTP_CANNOT_OPEN_DEST_FILE_FOR_WRITE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_CANNOT_OPEN_SOURCE_FILE_FOR_READ, 3592, 51, "FILESTATUS_ES_TFTP_CANNOT_OPEN_SOURCE_FILE_FOR_READ")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_CONNECTION_TO_SERVER_FAILED, 14332, 46, "FILESTATUS_ES_TFTP_CONNECTION_TO_SERVER_FAILED")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_DOWNLOADED_FILE_EMPTY, 12238, 40, "FILESTATUS_ES_TFTP_DOWNLOADED_FILE_EMPTY")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_ACESS_VIOLATION, 44939, 38, "FILESTATUS_ES_TFTP_ERR_ACESS_VIOLATION")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_DISK_FULL_OR_ALLOCATION_EXCEEDED, 59362, 55, "FILESTATUS_ES_TFTP_ERR_DISK_FULL_OR_ALLOCATION_EXCEEDED")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_FILE_ALREADY_EXISTS, 16530, 42, "FILESTATUS_ES_TFTP_ERR_FILE_ALREADY_EXISTS")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_FILE_NOT_FOUND, 57527, 37, "FILESTATUS_ES_TFTP_ERR_FILE_NOT_FOUND")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_ILLEGAL_TFTP_OPERATION, 61175, 45, "FILESTATUS_ES_TFTP_ERR_ILLEGAL_TFTP_OPERATION")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_NOT_DEFINED, 10073, 34, "FILESTATUS_ES_TFTP_ERR_NOT_DEFINED")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_NO_SUCH_USER, 42095, 35, "FILESTATUS_ES_TFTP_ERR_NO_SUCH_USER")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_ERR_UNKNOWN_TRANSFER_ID, 48476, 42, "FILESTATUS_ES_TFTP_ERR_UNKNOWN_TRANSFER_ID")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FAILED_TO_CLOSE_DEST_FILE, 29670, 44, "FILESTATUS_ES_TFTP_FAILED_TO_CLOSE_DEST_FILE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FAILED_TO_CLOSE_SOURCE_FILE, 45533, 46, "FILESTATUS_ES_TFTP_FAILED_TO_CLOSE_SOURCE_FILE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FAILED_TO_DISCONNECT_FROM_SERVER, 3555, 51, "FILESTATUS_ES_TFTP_FAILED_TO_DISCONNECT_FROM_SERVER")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FAILED_TO_READ_FROM_SOURCE_FILE, 4720, 50, "FILESTATUS_ES_TFTP_FAILED_TO_READ_FROM_SOURCE_FILE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FAILED_TO_WRITE_TO_DEST_FILE, 41705, 47, "FILESTATUS_ES_TFTP_FAILED_TO_WRITE_TO_DEST_FILE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_FILE_NOT_FOUND_ON_SOURCE, 24017, 43, "FILESTATUS_ES_TFTP_FILE_NOT_FOUND_ON_SOURCE")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_RECV_FAILED, 48374, 30, "FILESTATUS_ES_TFTP_RECV_FAILED")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_SEND_FAILED, 32936, 30, "FILESTATUS_ES_TFTP_SEND_FAILED")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_STATUS_OK, 34375, 28, "FILESTATUS_ES_TFTP_STATUS_OK")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_TL_NOT_INIT, 8863, 30, "FILESTATUS_ES_TFTP_TL_NOT_INIT")
QDEF(MP_QSTR_FILESTATUS_ES_TFTP_TRANSFER_PENDING, 58403, 35, "FILESTATUS_ES_TFTP_TRANSFER_PENDING")
QDEF(MP_QSTR_FName, 53540, 5, "FName")
QDEF(MP_QSTR_FName_make_from_buf, 24670, 19, "FName_make_from_buf")
QDEF(MP_QSTR_FP_PRIO_CRITICAL, 12764, 16, "FP_PRIO_CRITICAL")
QDEF(MP_QSTR_FP_PRIO_HIGH, 39993, 12, "FP_PRIO_HIGH")
QDEF(MP_QSTR_FP_PRIO_LOW, 16643, 11, "FP_PRIO_LOW")
QDEF(MP_QSTR_FP_PRIO_NORMAL, 42852, 14, "FP_PRIO_NORMAL")
QDEF(MP_QSTR_FileIO, 5573, 6, "FileIO")
QDEF(MP_QSTR_FileInfo, 4653, 8, "FileInfo")
QDEF(MP_QSTR_FileInfo_make_from_buf, 64983, 22, "FileInfo_make_from_buf")
QDEF(MP_QSTR_FileOp, 5564, 6, "FileOp")
QDEF(MP_QSTR_FileOp_make_from_buf, 40134, 20, "FileOp_make_from_buf")
QDEF(MP_QSTR_FileStatus, 15799, 10, "FileStatus")
QDEF(MP_QSTR_FileTransferSetup, 9327, 17, "FileTransferSetup")
QDEF(MP_QSTR_FileTransferSetup_make_from_buf, 34581, 31, "FileTransferSetup_make_from_buf")
QDEF(MP_QSTR_FileTransferStatus, 57660, 18, "FileTransferStatus")
QDEF(MP_QSTR_FileTransferStatus_make_from_buf, 34886, 32, "FileTransferStatus_make_from_buf")
QDEF(MP_QSTR_GnssSensorCmd, 42416, 13, "GnssSensorCmd")
QDEF(MP_QSTR_GnssSensorCmd_make_from_buf, 23498, 27, "GnssSensorCmd_make_from_buf")
QDEF(MP_QSTR_ImageFileInfo, 40266, 13, "ImageFileInfo")
QDEF(MP_QSTR_ImageFileInfo_make_from_buf, 50224, 27, "ImageFileInfo_make_from_buf")
QDEF(MP_QSTR_ImageTransferSetup, 59086, 18, "ImageTransferSetup")
QDEF(MP_QSTR_ImageTransferSetup_make_from_buf, 7860, 32, "ImageTransferSetup_make_from_buf")
QDEF(MP_QSTR_ImageTransferStatus, 36605, 19, "ImageTransferStatus")
QDEF(MP_QSTR_ImageTransferStatus_make_from_buf, 37255, 33, "ImageTransferStatus_make_from_buf")
QDEF(MP_QSTR_MODESWITHDEFCTRL_IDLE, 30050, 21, "MODESWITHDEFCTRL_IDLE")
QDEF(MP_QSTR_MODESWITHDEFCTRL_SAFE, 56375, 21, "MODESWITHDEFCTRL_SAFE")
QDEF(MP_QSTR_ModesWithDefCtrl, 9273, 16, "ModesWithDefCtrl")
QDEF(MP_QSTR_NODEPOWERSTATE_AUTO, 30269, 19, "NODEPOWERSTATE_AUTO")
QDEF(MP_QSTR_NODEPOWERSTATE_NO_CHANGE, 13386, 24, "NODEPOWERSTATE_NO_CHANGE")
QDEF(MP_QSTR_NODEPOWERSTATE_OFF, 44189, 18, "NODEPOWERSTATE_OFF")
QDEF(MP_QSTR_NODEPOWERSTATE_ON, 64883, 17, "NODEPOWERSTATE_ON")
QDEF(MP_QSTR_NODEPOWERSTATE_POWER_ON_PASS, 13405, 28, "NODEPOWERSTATE_POWER_ON_PASS")
QDEF(MP_QSTR_NodePowerState, 60685, 14, "NodePowerState")
QDEF(MP_QSTR_OPMODES_MODE_IDLE, 23917, 17, "OPMODES_MODE_IDLE")
QDEF(MP_QSTR_OPMODES_MODE_MISSION, 389, 20, "OPMODES_MODE_MISSION")
QDEF(MP_QSTR_OPMODES_MODE_SAFE, 33208, 17, "OPMODES_MODE_SAFE")
QDEF(MP_QSTR_OPMODES_MODE_SAFE_CONTROL, 9344, 25, "OPMODES_MODE_SAFE_CONTROL")
QDEF(MP_QSTR_OPMODES_MODE_SAFE_ENTRY, 25363, 23, "OPMODES_MODE_SAFE_ENTRY")
QDEF(MP_QSTR_OPMODES_MODE_SAFE_NO_CONTROL, 9566, 28, "OPMODES_MODE_SAFE_NO_CONTROL")
QDEF(MP_QSTR_OpModes, 5898, 7, "OpModes")
QDEF(MP_QSTR_OpStatusApp, 40335, 11, "OpStatusApp")
QDEF(MP_QSTR_OpStatusApp_make_from_buf, 53749, 25, "OpStatusApp_make_from_buf")
QDEF(MP_QSTR_OpStatusCommon, 42563, 14, "OpStatusCommon")
QDEF(MP_QSTR_OpStatusCommon_make_from_buf, 2489, 28, "OpStatusCommon_make_from_buf")
QDEF(MP_QSTR_OpenLoopCommandHxyzRW, 19100, 21, "OpenLoopCommandHxyzRW")
QDEF(MP_QSTR_OpenLoopCommandHxyzRW_make_from_buf, 49766, 35, "OpenLoopCommandHxyzRW_make_from_buf")
QDEF(MP_QSTR_OpenLoopCommandMtq, 9602, 18, "OpenLoopCommandMtq")
QDEF(MP_QSTR_OpenLoopCommandMtq_make_from_buf, 11128, 32, "OpenLoopCommandMtq_make_from_buf")
QDEF(MP_QSTR_OpenLoopCommandRwl, 33827, 18, "OpenLoopCommandRwl")
QDEF(MP_QSTR_OpenLoopCommandRwl_make_from_buf, 30681, 32, "OpenLoopCommandRwl_make_from_buf")
QDEF(MP_QSTR_OrbMode, 16121, 7, "OrbMode")
QDEF(MP_QSTR_OrbMode_make_from_buf, 53379, 21, "OrbMode_make_from_buf")
QDEF(MP_QSTR_PAYLOADOPRESULT_FAILED, 19585, 22, "PAYLOADOPRESULT_FAILED")
QDEF(MP_QSTR_PAYLOADOPRESULT_INVALID_PL_ID, 30274, 29, "PAYLOADOPRESULT_INVALID_PL_ID")
QDEF(MP_QSTR_PAYLOADOPRESULT_NOT_INIT, 32466, 24, "PAYLOADOPRESULT_NOT_INIT")
QDEF(MP_QSTR_PAYLOADOPRESULT_OK, 8038, 18, "PAYLOADOPRESULT_OK")
QDEF(MP_QSTR_PAYLOADOPRESULT_REFUSE_CMD, 49573, 26, "PAYLOADOPRESULT_REFUSE_CMD")
QDEF(MP_QSTR_PAYLOADSTATE_ERROR, 11611, 18, "PAYLOADSTATE_ERROR")
QDEF(MP_QSTR_PAYLOADSTATE_NOT_INIT, 30547, 21, "PAYLOADSTATE_NOT_INIT")
QDEF(MP_QSTR_PAYLOADSTATE_STARTED, 65218, 20, "PAYLOADSTATE_STARTED")
QDEF(MP_QSTR_PAYLOADSTATE_STARTING, 59267, 21, "PAYLOADSTATE_STARTING")
QDEF(MP_QSTR_PAYLOADSTATE_STOPPED, 51722, 20, "PAYLOADSTATE_STOPPED")
QDEF(MP_QSTR_PAYLOADSTATE_STOPPING, 55883, 21, "PAYLOADSTATE_STOPPING")
QDEF(MP_QSTR_PassThrough, 43535, 11, "PassThrough")
QDEF(MP_QSTR_PassThrough_make_from_buf, 48757, 25, "PassThrough_make_from_buf")
QDEF(MP_QSTR_PayloadInfo, 16613, 11, "PayloadInfo")
QDEF(MP_QSTR_PayloadInfo_make_from_buf, 43935, 25, "PayloadInfo_make_from_buf")
QDEF(MP_QSTR_PayloadOpResult, 16893, 15, "PayloadOpResult")
QDEF(MP_QSTR_PayloadStartCfg, 26537, 15, "PayloadStartCfg")
QDEF(MP_QSTR_PayloadStartCfg_make_from_buf, 33363, 29, "PayloadStartCfg_make_from_buf")
QDEF(MP_QSTR_PayloadState, 32412, 12, "PayloadState")
QDEF(MP_QSTR_PortDiagnostics, 25192, 15, "PortDiagnostics")
QDEF(MP_QSTR_PortDiagnostics_make_from_buf, 49554, 29, "PortDiagnostics_make_from_buf")
QDEF(MP_QSTR_PortMap, 20736, 7, "PortMap")
QDEF(MP_QSTR_PortMap_make_from_buf, 40954, 21, "PortMap_make_from_buf")
QDEF(MP_QSTR_PowerState, 23661, 10, "PowerState")
QDEF(MP_QSTR_PowerState_make_from_buf, 18199, 24, "PowerState_make_from_buf")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_FAULT_DETECTION_DISABLED, 44361, 44, "RETURN_STATUS_ERROR_FAULT_DETECTION_DISABLED")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_FAULT_LEVEL_ABOVE_AUTOCLEAR, 27542, 47, "RETURN_STATUS_ERROR_FAULT_LEVEL_ABOVE_AUTOCLEAR")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_INTERNAL, 48443, 28, "RETURN_STATUS_ERROR_INTERNAL")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_INVALID_AGENT_ID, 27769, 36, "RETURN_STATUS_ERROR_INVALID_AGENT_ID")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_INVALID_FAULT_ID, 25290, 36, "RETURN_STATUS_ERROR_INVALID_FAULT_ID")
QDEF(MP_QSTR_RETURN_STATUS_ERROR_INVALID_FDIR_LEVEL, 60354, 38, "RETURN_STATUS_ERROR_INVALID_FDIR_LEVEL")
QDEF(MP_QSTR_RETURN_STATUS_SUCCESS, 61848, 21, "RETURN_STATUS_SUCCESS")
QDEF(MP_QSTR_RefParams, 15304, 9, "RefParams")
QDEF(MP_QSTR_RefParams_make_from_buf, 51378, 23, "RefParams_make_from_buf")
QDEF(MP_QSTR_ReferenceFmcParam, 33161, 17, "ReferenceFmcParam")
QDEF(MP_QSTR_ReferenceFmcParam_make_from_buf, 28147, 31, "ReferenceFmcParam_make_from_buf")
QDEF(MP_QSTR_ReferenceIrcVector, 21263, 18, "ReferenceIrcVector")
QDEF(MP_QSTR_ReferenceIrcVector_make_from_buf, 10101, 32, "ReferenceIrcVector_make_from_buf")
QDEF(MP_QSTR_ReferenceRpy, 25013, 12, "ReferenceRpy")
QDEF(MP_QSTR_ReferenceRpy_make_from_buf, 50511, 26, "ReferenceRpy_make_from_buf")
QDEF(MP_QSTR_ReferenceTarget, 54079, 15, "ReferenceTarget")
QDEF(MP_QSTR_ReferenceTarget_make_from_buf, 36805, 29, "ReferenceTarget_make_from_buf")
QDEF(MP_QSTR_SAFEBOOL_FALSE, 27000, 14, "SAFEBOOL_FALSE")
QDEF(MP_QSTR_SAFEBOOL_TRUE, 24051, 13, "SAFEBOOL_TRUE")
QDEF(MP_QSTR_STANDARDRESULT_ERROR, 19248, 20, "STANDARDRESULT_ERROR")
QDEF(MP_QSTR_STANDARDRESULT_INVALID_ARGS, 45153, 27, "STANDARDRESULT_INVALID_ARGS")
QDEF(MP_QSTR_STANDARDRESULT_NOT_SUPPORTED, 48716, 28, "STANDARDRESULT_NOT_SUPPORTED")
QDEF(MP_QSTR_STANDARDRESULT_SUCCESS, 54827, 22, "STANDARDRESULT_SUCCESS")
QDEF(MP_QSTR_STATEMACHINEEVENTS_ADCS_RESETED, 33609, 31, "STATEMACHINEEVENTS_ADCS_RESETED")
QDEF(MP_QSTR_STATEMACHINEEVENTS_CHECK_COMPLETED, 43715, 34, "STATEMACHINEEVENTS_CHECK_COMPLETED")
QDEF(MP_QSTR_STATEMACHINEEVENTS_EVENT_DOWNLOAD_COMPLETED, 2178, 43, "STATEMACHINEEVENTS_EVENT_DOWNLOAD_COMPLETED")
QDEF(MP_QSTR_STATEMACHINEEVENTS_EVENT_MARKER_ACQUIRED, 65285, 40, "STATEMACHINEEVENTS_EVENT_MARKER_ACQUIRED")
QDEF(MP_QSTR_STATEMACHINEEVENTS_FDIR_COMPLETED, 14524, 33, "STATEMACHINEEVENTS_FDIR_COMPLETED")
QDEF(MP_QSTR_STATEMACHINEEVENTS_REQUEST_FDIR, 51424, 31, "STATEMACHINEEVENTS_REQUEST_FDIR")
QDEF(MP_QSTR_STATEMACHINEEVENTS_REQUEST_STATE_CHANGE, 3159, 39, "STATEMACHINEEVENTS_REQUEST_STATE_CHANGE")
QDEF(MP_QSTR_STATEMACHINEEVENTS_RESET, 34530, 24, "STATEMACHINEEVENTS_RESET")
QDEF(MP_QSTR_STATEMACHINEEVENTS_STATE_CHANGE_COMPLETED, 30027, 41, "STATEMACHINEEVENTS_STATE_CHANGE_COMPLETED")
QDEF(MP_QSTR_STATEMACHINESTATES_CHECK, 43498, 24, "STATEMACHINESTATES_CHECK")
QDEF(MP_QSTR_STATEMACHINESTATES_EVENT_DOWNLOAD, 25035, 33, "STATEMACHINESTATES_EVENT_DOWNLOAD")
QDEF(MP_QSTR_STATEMACHINESTATES_EVENT_MARKER_ACQUISITION, 7275, 43, "STATEMACHINESTATES_EVENT_MARKER_ACQUISITION")
QDEF(MP_QSTR_STATEMACHINESTATES_FDIR, 65397, 23, "STATEMACHINESTATES_FDIR")
QDEF(MP_QSTR_STATEMACHINESTATES_FIRMWARE_UPDATE, 5811, 34, "STATEMACHINESTATES_FIRMWARE_UPDATE")
QDEF(MP_QSTR_STATEMACHINESTATES_IDLE, 61672, 23, "STATEMACHINESTATES_IDLE")
QDEF(MP_QSTR_STATEMACHINESTATES_INIT, 10582, 23, "STATEMACHINESTATES_INIT")
QDEF(MP_QSTR_STATEMACHINESTATES_ROOT, 41002, 23, "STATEMACHINESTATES_ROOT")
QDEF(MP_QSTR_STATEMACHINESTATES_STATE_CHANGE, 19714, 31, "STATEMACHINESTATES_STATE_CHANGE")
QDEF(MP_QSTR_STATEMACHINESTATE_BOOTING, 32745, 25, "STATEMACHINESTATE_BOOTING")
QDEF(MP_QSTR_STATEMACHINESTATE_BUSY, 47810, 22, "STATEMACHINESTATE_BUSY")
QDEF(MP_QSTR_STATEMACHINESTATE_INACTIVE, 28340, 26, "STATEMACHINESTATE_INACTIVE")
QDEF(MP_QSTR_STATEMACHINESTATE_READY, 63476, 23, "STATEMACHINESTATE_READY")
QDEF(MP_QSTR_STATEMACHINESTATE_ROOT, 11993, 22, "STATEMACHINESTATE_ROOT")
QDEF(MP_QSTR_STATEMACHINESTATE_SYNCING, 17176, 25, "STATEMACHINESTATE_SYNCING")
QDEF(MP_QSTR_STOPMODE_EMERGENCY, 23912, 18, "STOPMODE_EMERGENCY")
QDEF(MP_QSTR_STOPMODE_NORMAL, 63122, 15, "STOPMODE_NORMAL")
QDEF(MP_QSTR_SYS_STATES_FAST_DETUMBLING, 10436, 26, "SYS_STATES_FAST_DETUMBLING")
QDEF(MP_QSTR_SYS_STATES_NORMAL_DETUMBLING, 53879, 28, "SYS_STATES_NORMAL_DETUMBLING")
QDEF(MP_QSTR_SYS_STATES_NO_CONTROL, 27361, 21, "SYS_STATES_NO_CONTROL")
QDEF(MP_QSTR_SYS_STATES_SUN_TRACKING, 2528, 23, "SYS_STATES_SUN_TRACKING")
QDEF(MP_QSTR_SYS_STATES_TARGET_TRACKING, 46809, 26, "SYS_STATES_TARGET_TRACKING")
QDEF(MP_QSTR_SYS_STATES_THREE_AXIS, 24746, 21, "SYS_STATES_THREE_AXIS")
QDEF(MP_QSTR_SYS_STATES_USER1, 45144, 16, "SYS_STATES_USER1")
QDEF(MP_QSTR_SYS_STATES_USER2, 45147, 16, "SYS_STATES_USER2")
QDEF(MP_QSTR_SYS_STATES_USER3, 45146, 16, "SYS_STATES_USER3")
QDEF(MP_QSTR_SYS_STATES_VERY_FAST_DETUMBLING, 2403, 31, "SYS_STATES_VERY_FAST_DETUMBLING")
QDEF(MP_QSTR_SYS_STATES_Y_MOMENTUM, 1238, 21, "SYS_STATES_Y_MOMENTUM")
QDEF(MP_QSTR_SYS_STATES_Y_MOMENTUM_FULL_STATE_EKF, 59557, 36, "SYS_STATES_Y_MOMENTUM_FULL_STATE_EKF")
QDEF(MP_QSTR_SYS_STATES_Y_THOMSON, 50866, 20, "SYS_STATES_Y_THOMSON")
QDEF(MP_QSTR_SYS_STATES_Y_THOMSON_MEMS_RATE, 518, 30, "SYS_STATES_Y_THOMSON_MEMS_RATE")
QDEF(MP_QSTR_SafeBool, 38362, 8, "SafeBool")
QDEF(MP_QSTR_SimSensorRaw, 44352, 12, "SimSensorRaw")
QDEF(MP_QSTR_SimSensorRaw_make_from_buf, 31290, 26, "SimSensorRaw_make_from_buf")
QDEF(MP_QSTR_StandardResult, 57719, 14, "StandardResult")
QDEF(MP_QSTR_StateMachineEvents, 53800, 18, "StateMachineEvents")
QDEF(MP_QSTR_StateMachineState, 27616, 17, "StateMachineState")
QDEF(MP_QSTR_StateMachineStates, 59283, 18, "StateMachineStates")
QDEF(MP_QSTR_StopAsyncIteration, 61676, 18, "StopAsyncIteration")
QDEF(MP_QSTR_StopMode, 60606, 8, "StopMode")
QDEF(MP_QSTR_StringIO, 30326, 8, "StringIO")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_AURIGA, 2771, 81, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_AURIGA")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_COMPUTER, 44691, 88, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_COMPUTER")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_IR, 15087, 82, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_IR")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_MAG_COMPACT, 31111, 91, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_MAG_COMPACT")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_MAG_DEPLOY, 51691, 90, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_MAG_DEPLOY")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE, 6996, 84, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_NSSRWL, 36172, 91, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_NSSRWL")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_PST3S, 4316, 90, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_PST3S")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD, 15818, 89, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_LITEFUFORS, 15834, 100, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_LITEFUFORS")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_NSSRWL, 28050, 96, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_NSSRWL")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_PST3S, 1858, 95, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_QUAD_PST3S")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_SLT, 52256, 88, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_NODE_SLT")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_SENSE, 53530, 85, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_SENSE")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_STAR, 63680, 84, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_STAR")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_WHEEL, 36967, 85, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_CUBE_WHEEL")
QDEF(MP_QSTR_TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_INVALID, 64331, 82, "TCTLMCOMMONFRAMEWORKENUMS_NODETYPE_TCTLM_COMMON_FRAMEWORK_ENUMS__NODE_TYPE_INVALID")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QDOWNLOAD, 493, 93, "TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QDOWNLOAD")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QERASE, 8697, 90, "TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QERASE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QIDLE, 41757, 89, "TCTLMCUBECOMPUTERCOMMON3_EVENTREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__EVT_READ_QIDLE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_BUSY_DOWNLOAD, 3488, 93, "TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_BUSY_DOWNLOAD")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_BUSY_STORE, 54507, 90, "TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_BUSY_STORE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_IDLE, 24146, 84, "TCTLMCUBECOMPUTERCOMMON3_IMAGETRANSFERSTATE_TCTLM_CUBE_COMPUTER_COMMON_3__STATE_IDLE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_COUNTER_NEXT_X, 37087, 94, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_COUNTER_NEXT_X")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_FIRST_X, 58121, 87, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_FIRST_X")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_LAST_X, 36409, 86, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_LAST_X")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_NONE, 19134, 84, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_NONE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_TIME_NEXT_X, 62174, 91, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_TIME_NEXT_X")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_TIME_SPAN, 5490, 89, "TCTLMCUBECOMPUTERCOMMON3_LOGREADFILTERTYPE_TCTLM_CUBE_COMPUTER_COMMON_3__FILTER_TIME_SPAN")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QDOWNLOAD, 31682, 94, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QDOWNLOAD")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QERASE, 62006, 91, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QERASE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QIDLE, 44850, 90, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGREADQUEUESTATE_TCTLM_CUBE_COMPUTER_COMMON_3__TLM_READ_QIDLE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL1S, 28900, 92, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL1S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL2S, 28679, 92, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL2S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL3S, 28710, 92, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL3S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL4S, 28737, 92, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL4S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL5S, 28768, 92, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL5S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_100S, 57787, 95, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_100S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_10S, 17547, 94, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_10S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_200MS, 30613, 96, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_200MS")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_20S, 22920, 94, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_20S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_50S, 21903, 94, "TCTLMCUBECOMPUTERCOMMON3_TLMLOGRETURNINTERVALVALUES_TCTLM_CUBE_COMPUTER_COMMON_3__INTERVAL_50S")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__BUSY, 54162, 85, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__BUSY")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__IDLE, 57675, 85, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__IDLE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__INIT, 59381, 85, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__INIT")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__LOCKED, 55909, 87, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPSTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__LOCKED")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_BUSY_BIN, 119, 104, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_BUSY_BIN")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_BUSY_CFG, 1104, 104, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_BUSY_CFG")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_IDLE, 48820, 100, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_IDLE")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT, 38666, 100, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT_BIN, 3344, 104, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT_BIN")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT_CFG, 6071, 104, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_INIT_CFG")
QDEF(MP_QSTR_TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_TRANS, 34762, 101, "TCTLMCUBECOMPUTERCONTROLPROGRAM8_FTPUPGRADESTATE_TCTLM_CUBE_COMPUTER_CONTROL_PROGRAM_8__UPGRADE_TRANS")
QDEF(MP_QSTR_TELEMETRYINSTANCE_TLM_INST_0, 62361, 28, "TELEMETRYINSTANCE_TLM_INST_0")
QDEF(MP_QSTR_TELEMETRYINSTANCE_TLM_INST_1, 62360, 28, "TELEMETRYINSTANCE_TLM_INST_1")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_ANGVEL_MAX, 21009, 30, "THRESHOLDVALUETYPES_ANGVEL_MAX")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_ANGVEL_MIN, 20751, 30, "THRESHOLDVALUETYPES_ANGVEL_MIN")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_ANGVEL_Y_THOMSON_HIGH, 25886, 41, "THRESHOLDVALUETYPES_ANGVEL_Y_THOMSON_HIGH")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_ANGVEL_Y_THOMSON_LOW, 9156, 40, "THRESHOLDVALUETYPES_ANGVEL_Y_THOMSON_LOW")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_DEFAULT, 61574, 27, "THRESHOLDVALUETYPES_DEFAULT")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_TBATT_SAFE_LOWER, 29064, 36, "THRESHOLDVALUETYPES_TBATT_SAFE_LOWER")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_TBATT_SAFE_UPPER, 5289, 36, "THRESHOLDVALUETYPES_TBATT_SAFE_UPPER")
QDEF(MP_QSTR_THRESHOLDVALUETYPES_VBATT_SAFE, 54518, 30, "THRESHOLDVALUETYPES_VBATT_SAFE")
QDEF(MP_QSTR_TLM_FILE_LOGGING_TYPE_SIZE_LIMIT, 41058, 32, "TLM_FILE_LOGGING_TYPE_SIZE_LIMIT")
QDEF(MP_QSTR_TctlmCommonFrameworkEnums_NodeType, 33777, 34, "TctlmCommonFrameworkEnums_NodeType")
QDEF(MP_QSTR_TctlmCubeCommonBaseBootloader5_Errors, 48200, 37, "TctlmCubeCommonBaseBootloader5_Errors")
QDEF(MP_QSTR_TctlmCubeCommonBaseBootloader5_Errors_make_from_buf, 10546, 51, "TctlmCubeCommonBaseBootloader5_Errors_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_EventLogFilterTransferSetup, 29172, 52, "TctlmCubeComputerCommon3_EventLogFilterTransferSetup")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_EventLogFilterTransferSetup_make_from_buf, 47630, 66, "TctlmCubeComputerCommon3_EventLogFilterTransferSetup_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_EventLogStatus, 38732, 39, "TctlmCubeComputerCommon3_EventLogStatus")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_EventLogStatus_make_from_buf, 46390, 53, "TctlmCubeComputerCommon3_EventLogStatus_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_EventReadQueueState, 30024, 44, "TctlmCubeComputerCommon3_EventReadQueueState")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_ImageTransferState, 14187, 43, "TctlmCubeComputerCommon3_ImageTransferState")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_ImageTransferStatus, 9896, 44, "TctlmCubeComputerCommon3_ImageTransferStatus")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_ImageTransferStatus_make_from_buf, 17618, 58, "TctlmCubeComputerCommon3_ImageTransferStatus_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_LogReadFilterType, 23806, 42, "TctlmCubeComputerCommon3_LogReadFilterType")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TelemetryLogTransferSetup, 30743, 50, "TctlmCubeComputerCommon3_TelemetryLogTransferSetup")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TelemetryLogTransferSetup_make_from_buf, 25709, 64, "TctlmCubeComputerCommon3_TelemetryLogTransferSetup_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TelemtryLogStatus, 12874, 42, "TctlmCubeComputerCommon3_TelemtryLogStatus")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TelemtryLogStatus_make_from_buf, 6448, 56, "TctlmCubeComputerCommon3_TelemtryLogStatus_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TlmLogReadQueueState, 59797, 45, "TctlmCubeComputerCommon3_TlmLogReadQueueState")
QDEF(MP_QSTR_TctlmCubeComputerCommon3_TlmLogReturnIntervalValues, 60780, 51, "TctlmCubeComputerCommon3_TlmLogReturnIntervalValues")
QDEF(MP_QSTR_TctlmCubeComputerControlProgram8_FileTransferStatus, 57244, 51, "TctlmCubeComputerControlProgram8_FileTransferStatus")
QDEF(MP_QSTR_TctlmCubeComputerControlProgram8_FileTransferStatus_make_from_buf, 5990, 65, "TctlmCubeComputerControlProgram8_FileTransferStatus_make_from_buf")
QDEF(MP_QSTR_TctlmCubeComputerControlProgram8_FtpState, 52912, 41, "TctlmCubeComputerControlProgram8_FtpState")
QDEF(MP_QSTR_TctlmCubeComputerControlProgram8_FtpUpgradeState, 18560, 48, "TctlmCubeComputerControlProgram8_FtpUpgradeState")
QDEF(MP_QSTR_TelemetryInstance, 20131, 17, "TelemetryInstance")
QDEF(MP_QSTR_TelemetryLogTransferSetup, 52994, 25, "TelemetryLogTransferSetup")
QDEF(MP_QSTR_TelemetryLogTransferSetup_make_from_buf, 29944, 39, "TelemetryLogTransferSetup_make_from_buf")
QDEF(MP_QSTR_TelemtryLogInclusionMasks, 14666, 25, "TelemtryLogInclusionMasks")
QDEF(MP_QSTR_TelemtryLogInclusionMasks_make_from_buf, 24624, 39, "TelemtryLogInclusionMasks_make_from_buf")
QDEF(MP_QSTR_TelemtryLogStatus, 5151, 17, "TelemtryLogStatus")
QDEF(MP_QSTR_TelemtryLogStatus_make_from_buf, 24677, 31, "TelemtryLogStatus_make_from_buf")
QDEF(MP_QSTR_ThresholdValueTypes, 34674, 19, "ThresholdValueTypes")
QDEF(MP_QSTR_ThresholdValues, 44490, 15, "ThresholdValues")
QDEF(MP_QSTR_ThresholdValues_make_from_buf, 46256, 29, "ThresholdValues_make_from_buf")
QDEF(MP_QSTR_TlmAcpExecution, 51728, 15, "TlmAcpExecution")
QDEF(MP_QSTR_TlmAcpExecution_make_from_buf, 37098, 29, "TlmAcpExecution_make_from_buf")
QDEF(MP_QSTR_TlmAsgp4, 63297, 8, "TlmAsgp4")
QDEF(MP_QSTR_TlmAsgp4_make_from_buf, 8379, 22, "TlmAsgp4_make_from_buf")
QDEF(MP_QSTR_TlmController, 16012, 13, "TlmController")
QDEF(MP_QSTR_TlmController_make_from_buf, 65142, 27, "TlmController_make_from_buf")
QDEF(MP_QSTR_TlmCubeComputerHealth, 29338, 21, "TlmCubeComputerHealth")
QDEF(MP_QSTR_TlmCubeComputerHealth_make_from_buf, 20576, 35, "TlmCubeComputerHealth_make_from_buf")
QDEF(MP_QSTR_TlmCubeMagHealth, 38774, 16, "TlmCubeMagHealth")
QDEF(MP_QSTR_TlmCubeMagHealth_make_from_buf, 22668, 30, "TlmCubeMagHealth_make_from_buf")
QDEF(MP_QSTR_TlmEstimatorBackup, 52048, 18, "TlmEstimatorBackup")
QDEF(MP_QSTR_TlmEstimatorBackup_make_from_buf, 53290, 32, "TlmEstimatorBackup_make_from_buf")
QDEF(MP_QSTR_TlmEstimatorMain, 64213, 16, "TlmEstimatorMain")
QDEF(MP_QSTR_TlmEstimatorMainHighRes, 50207, 23, "TlmEstimatorMainHighRes")
QDEF(MP_QSTR_TlmEstimatorMainHighRes_make_from_buf, 4197, 37, "TlmEstimatorMainHighRes_make_from_buf")
QDEF(MP_QSTR_TlmEstimatorMain_make_from_buf, 27951, 30, "TlmEstimatorMain_make_from_buf")
QDEF(MP_QSTR_TlmExecutionPoint, 1806, 17, "TlmExecutionPoint")
QDEF(MP_QSTR_TlmExecutionPoint_make_from_buf, 32244, 31, "TlmExecutionPoint_make_from_buf")
QDEF(MP_QSTR_TlmExtSensorRaw, 843, 15, "TlmExtSensorRaw")
QDEF(MP_QSTR_TlmExtSensorRaw_make_from_buf, 34481, 29, "TlmExtSensorRaw_make_from_buf")
QDEF(MP_QSTR_TlmFssCubeSenseSunHealth, 59645, 24, "TlmFssCubeSenseSunHealth")
QDEF(MP_QSTR_TlmFssCubeSenseSunHealth_make_from_buf, 27527, 38, "TlmFssCubeSenseSunHealth_make_from_buf")
QDEF(MP_QSTR_TlmFssCubeSenseSunRaw, 18917, 21, "TlmFssCubeSenseSunRaw")
QDEF(MP_QSTR_TlmFssCubeSenseSunRaw_make_from_buf, 29855, 35, "TlmFssCubeSenseSunRaw_make_from_buf")
QDEF(MP_QSTR_TlmGnssRaw, 62557, 10, "TlmGnssRaw")
QDEF(MP_QSTR_TlmGnssRaw_make_from_buf, 26279, 24, "TlmGnssRaw_make_from_buf")
QDEF(MP_QSTR_TlmGnssUartStatus, 42847, 17, "TlmGnssUartStatus")
QDEF(MP_QSTR_TlmGnssUartStatus_make_from_buf, 21413, 31, "TlmGnssUartStatus_make_from_buf")
QDEF(MP_QSTR_TlmGyrLitefuforsRaw, 52599, 19, "TlmGyrLitefuforsRaw")
QDEF(MP_QSTR_TlmGyrLitefuforsRaw_make_from_buf, 18445, 33, "TlmGyrLitefuforsRaw_make_from_buf")
QDEF(MP_QSTR_TlmHil, 797, 6, "TlmHil")
QDEF(MP_QSTR_TlmHil_make_from_buf, 47207, 20, "TlmHil_make_from_buf")
QDEF(MP_QSTR_TlmHssCubeSenseEarthHealth, 33649, 26, "TlmHssCubeSenseEarthHealth")
QDEF(MP_QSTR_TlmHssCubeSenseEarthHealth_make_from_buf, 38155, 40, "TlmHssCubeSenseEarthHealth_make_from_buf")
QDEF(MP_QSTR_TlmHssCubeSenseEarthRaw, 39145, 23, "TlmHssCubeSenseEarthRaw")
QDEF(MP_QSTR_TlmHssCubeSenseEarthRaw_make_from_buf, 62099, 37, "TlmHssCubeSenseEarthRaw_make_from_buf")
QDEF(MP_QSTR_TlmLitefuforsHealth, 22467, 19, "TlmLitefuforsHealth")
QDEF(MP_QSTR_TlmLitefuforsHealth_make_from_buf, 23353, 33, "TlmLitefuforsHealth_make_from_buf")
QDEF(MP_QSTR_TlmModels, 26796, 9, "TlmModels")
QDEF(MP_QSTR_TlmModels_make_from_buf, 30678, 23, "TlmModels_make_from_buf")
QDEF(MP_QSTR_TlmNodeInitState, 23357, 16, "TlmNodeInitState")
QDEF(MP_QSTR_TlmNodeInitState_make_from_buf, 48839, 30, "TlmNodeInitState_make_from_buf")
QDEF(MP_QSTR_TlmNssRwlHealth, 43243, 15, "TlmNssRwlHealth")
QDEF(MP_QSTR_TlmNssRwlHealth_make_from_buf, 31377, 29, "TlmNssRwlHealth_make_from_buf")
QDEF(MP_QSTR_TlmRwlHealth, 30469, 12, "TlmRwlHealth")
QDEF(MP_QSTR_TlmRwlHealth_make_from_buf, 5247, 26, "TlmRwlHealth_make_from_buf")
QDEF(MP_QSTR_TlmRwlNssRwlRaw, 1914, 15, "TlmRwlNssRwlRaw")
QDEF(MP_QSTR_TlmRwlNssRwlRaw_make_from_buf, 46976, 29, "TlmRwlNssRwlRaw_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalCss, 1483, 15, "TlmSensorCalCss")
QDEF(MP_QSTR_TlmSensorCalCss_make_from_buf, 59697, 29, "TlmSensorCalCss_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalFss, 6798, 15, "TlmSensorCalFss")
QDEF(MP_QSTR_TlmSensorCalFss_make_from_buf, 45428, 29, "TlmSensorCalFss_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalGnss, 30977, 16, "TlmSensorCalGnss")
QDEF(MP_QSTR_TlmSensorCalGnss_make_from_buf, 9595, 30, "TlmSensorCalGnss_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalGyro, 50795, 16, "TlmSensorCalGyro")
QDEF(MP_QSTR_TlmSensorCalGyro_make_from_buf, 14353, 30, "TlmSensorCalGyro_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalHss, 52992, 15, "TlmSensorCalHss")
QDEF(MP_QSTR_TlmSensorCalHss_make_from_buf, 40442, 29, "TlmSensorCalHss_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalMag, 64131, 15, "TlmSensorCalMag")
QDEF(MP_QSTR_TlmSensorCalMag_make_from_buf, 7673, 29, "TlmSensorCalMag_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalRwl, 18945, 15, "TlmSensorCalRwl")
QDEF(MP_QSTR_TlmSensorCalRwl_make_from_buf, 46715, 29, "TlmSensorCalRwl_make_from_buf")
QDEF(MP_QSTR_TlmSensorCalStr, 18173, 15, "TlmSensorCalStr")
QDEF(MP_QSTR_TlmSensorCalStr_make_from_buf, 18823, 29, "TlmSensorCalStr_make_from_buf")
QDEF(MP_QSTR_TlmSensorRawCss, 19521, 15, "TlmSensorRawCss")
QDEF(MP_QSTR_TlmSensorRawCss_make_from_buf, 13755, 29, "TlmSensorRawCss_make_from_buf")
QDEF(MP_QSTR_TlmSensorRawGyro, 3873, 16, "TlmSensorRawGyro")
QDEF(MP_QSTR_TlmSensorRawGyro_make_from_buf, 59867, 30, "TlmSensorRawGyro_make_from_buf")
QDEF(MP_QSTR_TlmSensorRawMag, 29833, 15, "TlmSensorRawMag")
QDEF(MP_QSTR_TlmSensorRawMag_make_from_buf, 41203, 29, "TlmSensorRawMag_make_from_buf")
QDEF(MP_QSTR_TlmSensorRawRwl, 28555, 15, "TlmSensorRawRwl")
QDEF(MP_QSTR_TlmSensorRawRwl_make_from_buf, 45809, 29, "TlmSensorRawRwl_make_from_buf")
QDEF(MP_QSTR_TlmStrAurigaHealth, 32528, 18, "TlmStrAurigaHealth")
QDEF(MP_QSTR_TlmStrAurigaHealth_make_from_buf, 1514, 32, "TlmStrAurigaHealth_make_from_buf")
QDEF(MP_QSTR_TlmStrCubeAurigaRaw, 59865, 19, "TlmStrCubeAurigaRaw")
QDEF(MP_QSTR_TlmStrCubeAurigaRaw_make_from_buf, 35619, 33, "TlmStrCubeAurigaRaw_make_from_buf")
QDEF(MP_QSTR_TlmStrCubeStarRaw, 53412, 17, "TlmStrCubeStarRaw")
QDEF(MP_QSTR_TlmStrCubeStarRaw_make_from_buf, 32734, 31, "TlmStrCubeStarRaw_make_from_buf")
QDEF(MP_QSTR_TlmStrHealth, 46137, 12, "TlmStrHealth")
QDEF(MP_QSTR_TlmStrHealth_make_from_buf, 26307, 26, "TlmStrHealth_make_from_buf")
QDEF(MP_QSTR_TlmStrPst3sHealth, 10254, 17, "TlmStrPst3sHealth")
QDEF(MP_QSTR_TlmStrPst3sHealth_make_from_buf, 24308, 31, "TlmStrPst3sHealth_make_from_buf")
QDEF(MP_QSTR_TlmStrPst3sRaw, 47798, 14, "TlmStrPst3sRaw")
QDEF(MP_QSTR_TlmStrPst3sRaw_make_from_buf, 39372, 28, "TlmStrPst3sRaw_make_from_buf")
QDEF(MP_QSTR_TlmTorquerCurrents, 5360, 18, "TlmTorquerCurrents")
QDEF(MP_QSTR_TlmTorquerCurrents_make_from_buf, 11274, 32, "TlmTorquerCurrents_make_from_buf")
QDEF(MP_QSTR_UnsolicitedEventSetup, 38003, 21, "UnsolicitedEventSetup")
QDEF(MP_QSTR_UnsolicitedEventSetup_make_from_buf, 56841, 35, "UnsolicitedEventSetup_make_from_buf")
QDEF(MP_QSTR_UnsolicitedTlmSetup, 30090, 19, "UnsolicitedTlmSetup")
QDEF(MP_QSTR_UnsolicitedTlmSetup_make_from_buf, 56176, 33, "UnsolicitedTlmSetup_make_from_buf")
QDEF(MP_QSTR_Vfs_es_fm_mng, 4704, 13, "Vfs_es_fm_mng")
QDEF(MP_QSTR__machine, 19391, 8, "_machine")
QDEF(MP_QSTR__mpy, 10590, 4, "_mpy")
QDEF(MP_QSTR_acos, 40987, 4, "acos")
QDEF(MP_QSTR_add, 12868, 3, "add")
QDEF(MP_QSTR_argv, 50887, 4, "argv")
QDEF(MP_QSTR_array, 29308, 5, "array")
QDEF(MP_QSTR_asin, 58704, 4, "asin")
QDEF(MP_QSTR_atan, 48671, 4, "atan")
QDEF(MP_QSTR_atan2, 33229, 5, "atan2")
QDEF(MP_QSTR_bin, 18656, 3, "bin")
QDEF(MP_QSTR_bound_method, 41623, 12, "bound_method")
QDEF(MP_QSTR_buffering, 56101, 9, "buffering")
QDEF(MP_QSTR_byteorder, 39265, 9, "byteorder")
QDEF(MP_QSTR_calcsize, 14413, 8, "calcsize")
QDEF(MP_QSTR_ceil, 45062, 4, "ceil")
QDEF(MP_QSTR_chdir, 45745, 5, "chdir")
QDEF(MP_QSTR_closure, 51828, 7, "closure")
QDEF(MP_QSTR_collect, 26011, 7, "collect")
QDEF(MP_QSTR_collections, 51424, 11, "collections")
QDEF(MP_QSTR_complex, 40389, 7, "complex")
QDEF(MP_QSTR_copysign, 5171, 8, "copysign")
QDEF(MP_QSTR_cos, 19578, 3, "cos")
QDEF(MP_QSTR_cp_send, 45205, 7, "cp_send")
QDEF(MP_QSTR_csp_send, 53542, 8, "csp_send")
QDEF(MP_QSTR_cube_computer_fw_update_status, 23207, 30, "cube_computer_fw_update_status")
QDEF(MP_QSTR_cube_computer_fw_update_status_make_from_buf, 8029, 44, "cube_computer_fw_update_status_make_from_buf")
QDEF(MP_QSTR_cube_node_fw_update_status, 46592, 26, "cube_node_fw_update_status")
QDEF(MP_QSTR_cube_node_fw_update_status_make_from_buf, 50426, 40, "cube_node_fw_update_status_make_from_buf")
QDEF(MP_QSTR_decode, 22953, 6, "decode")
QDEF(MP_QSTR_default, 32206, 7, "default")
QDEF(MP_QSTR_degrees, 16642, 7, "degrees")
QDEF(MP_QSTR_delattr, 51419, 7, "delattr")
QDEF(MP_QSTR_deleter, 56174, 7, "deleter")
QDEF(MP_QSTR_dict_view, 43309, 9, "dict_view")
QDEF(MP_QSTR_difference, 9330, 10, "difference")
QDEF(MP_QSTR_difference_update, 64156, 17, "difference_update")
QDEF(MP_QSTR_disable, 30353, 7, "disable")
QDEF(MP_QSTR_discard, 28943, 7, "discard")
QDEF(MP_QSTR_doc, 7981, 3, "doc")
QDEF(MP_QSTR_download_event_status, 55465, 21, "download_event_status")
QDEF(MP_QSTR_download_event_status_make_from_buf, 45907, 35, "download_event_status_make_from_buf")
QDEF(MP_QSTR_download_telemetry_status, 2602, 25, "download_telemetry_status")
QDEF(MP_QSTR_download_telemetry_status_make_from_buf, 16464, 39, "download_telemetry_status_make_from_buf")
QDEF(MP_QSTR_e, 46528, 1, "e")
QDEF(MP_QSTR_enable, 56836, 6, "enable")
QDEF(MP_QSTR_encode, 51779, 6, "encode")
QDEF(MP_QSTR_encoding, 39942, 8, "encoding")
QDEF(MP_QSTR_enumerate, 47729, 9, "enumerate")
QDEF(MP_QSTR_errno, 4545, 5, "errno")
QDEF(MP_QSTR_events, 41626, 6, "events")
QDEF(MP_QSTR_events_enum, 42646, 11, "events_enum")
QDEF(MP_QSTR_events_make_from_buf, 32864, 20, "events_make_from_buf")
QDEF(MP_QSTR_executable, 12821, 10, "executable")
QDEF(MP_QSTR_exit, 48773, 4, "exit")
QDEF(MP_QSTR_exp, 9416, 3, "exp")
QDEF(MP_QSTR_fabs, 4755, 4, "fabs")
QDEF(MP_QSTR_fdir_stat, 61681, 9, "fdir_stat")
QDEF(MP_QSTR_fdir_stat_make_from_buf, 41611, 23, "fdir_stat_make_from_buf")
QDEF(MP_QSTR_file, 13507, 4, "file")
QDEF(MP_QSTR_filter, 48677, 6, "filter")
QDEF(MP_QSTR_float, 17461, 5, "float")
QDEF(MP_QSTR_floor, 18045, 5, "floor")
QDEF(MP_QSTR_flush, 49505, 5, "flush")
QDEF(MP_QSTR_fmng, 17415, 4, "fmng")
QDEF(MP_QSTR_fmod, 17637, 4, "fmod")
QDEF(MP_QSTR_fp_send, 58192, 7, "fp_send")
QDEF(MP_QSTR_frexp, 38940, 5, "frexp")
QDEF(MP_QSTR_fromkeys, 48439, 8, "fromkeys")
QDEF(MP_QSTR_function, 551, 8, "function")
QDEF(MP_QSTR_gc, 28257, 2, "gc")
QDEF(MP_QSTR_generator, 50070, 9, "generator")
QDEF(MP_QSTR_get_AbstractTypeError, 2124, 21, "get_AbstractTypeError")
QDEF(MP_QSTR_get_AdcCurrent, 55971, 14, "get_AdcCurrent")
QDEF(MP_QSTR_get_AddrAssignError, 41638, 19, "get_AddrAssignError")
QDEF(MP_QSTR_get_AllocSize, 55588, 13, "get_AllocSize")
QDEF(MP_QSTR_get_Asgp4AP, 24780, 11, "get_Asgp4AP")
QDEF(MP_QSTR_get_Asgp4BatchCtr, 26788, 17, "get_Asgp4BatchCtr")
QDEF(MP_QSTR_get_Asgp4Bstar, 58443, 14, "get_Asgp4Bstar")
QDEF(MP_QSTR_get_Asgp4Eccen, 16915, 14, "get_Asgp4Eccen")
QDEF(MP_QSTR_get_Asgp4Epoch, 48748, 14, "get_Asgp4Epoch")
QDEF(MP_QSTR_get_Asgp4Error, 16357, 14, "get_Asgp4Error")
QDEF(MP_QSTR_get_Asgp4Incl, 18965, 13, "get_Asgp4Incl")
QDEF(MP_QSTR_get_Asgp4MA, 24401, 11, "get_Asgp4MA")
QDEF(MP_QSTR_get_Asgp4MM, 24413, 11, "get_Asgp4MM")
QDEF(MP_QSTR_get_Asgp4PosDelta, 25321, 17, "get_Asgp4PosDelta")
QDEF(MP_QSTR_get_Asgp4Raan, 13921, 13, "get_Asgp4Raan")
QDEF(MP_QSTR_get_Backend, 22088, 11, "get_Backend")
QDEF(MP_QSTR_get_BatchSize, 59989, 13, "get_BatchSize")
QDEF(MP_QSTR_get_BatteryVoltage, 62019, 18, "get_BatteryVoltage")
QDEF(MP_QSTR_get_BusyError, 33865, 13, "get_BusyError")
QDEF(MP_QSTR_get_BytesReceived, 64986, 17, "get_BytesReceived")
QDEF(MP_QSTR_get_CanCurrent, 39561, 14, "get_CanCurrent")
QDEF(MP_QSTR_get_CaptureError, 20944, 16, "get_CaptureError")
QDEF(MP_QSTR_get_CfgSerialError, 14614, 18, "get_CfgSerialError")
QDEF(MP_QSTR_get_CmdEciVecX, 23777, 14, "get_CmdEciVecX")
QDEF(MP_QSTR_get_CmdEciVecY, 23776, 14, "get_CmdEciVecY")
QDEF(MP_QSTR_get_CmdEciVecZ, 23779, 14, "get_CmdEciVecZ")
QDEF(MP_QSTR_get_CmdFmcFactor, 42723, 16, "get_CmdFmcFactor")
QDEF(MP_QSTR_get_CmdFmcRoll, 51827, 14, "get_CmdFmcRoll")
QDEF(MP_QSTR_get_CmdFmcUnixNs, 857, 16, "get_CmdFmcUnixNs")
QDEF(MP_QSTR_get_CmdFmcUnixSeconds, 31079, 21, "get_CmdFmcUnixSeconds")
QDEF(MP_QSTR_get_CmdRpyPitch, 53851, 15, "get_CmdRpyPitch")
QDEF(MP_QSTR_get_CmdRpyRoll, 50816, 14, "get_CmdRpyRoll")
QDEF(MP_QSTR_get_CmdRpyYaw, 34162, 13, "get_CmdRpyYaw")
QDEF(MP_QSTR_get_CmdTargetAltitude, 871, 21, "get_CmdTargetAltitude")
QDEF(MP_QSTR_get_CmdTargetLatitude, 58311, 21, "get_CmdTargetLatitude")
QDEF(MP_QSTR_get_CmdTargetLongitude, 57684, 22, "get_CmdTargetLongitude")
QDEF(MP_QSTR_get_Component, 25315, 13, "get_Component")
QDEF(MP_QSTR_get_ConModeActive, 47393, 17, "get_ConModeActive")
QDEF(MP_QSTR_get_ConModeAuto, 35426, 15, "get_ConModeAuto")
QDEF(MP_QSTR_get_ConModeDefault, 17670, 18, "get_ConModeDefault")
QDEF(MP_QSTR_get_ConModeSafe, 5756, 15, "get_ConModeSafe")
QDEF(MP_QSTR_get_ConfigInvalidError, 11631, 22, "get_ConfigInvalidError")
QDEF(MP_QSTR_get_ConfigPersistError, 59684, 22, "get_ConfigPersistError")
QDEF(MP_QSTR_get_ControlMode, 25480, 15, "get_ControlMode")
QDEF(MP_QSTR_get_Crc, 53342, 7, "get_Crc")
QDEF(MP_QSTR_get_Css0Raw, 26939, 11, "get_Css0Raw")
QDEF(MP_QSTR_get_Css1Raw, 60762, 11, "get_Css1Raw")
QDEF(MP_QSTR_get_Css2Raw, 33401, 11, "get_Css2Raw")
QDEF(MP_QSTR_get_Css3Raw, 50328, 11, "get_Css3Raw")
QDEF(MP_QSTR_get_Css4Raw, 14271, 11, "get_Css4Raw")
QDEF(MP_QSTR_get_Css5Raw, 48094, 11, "get_Css5Raw")
QDEF(MP_QSTR_get_Css6Raw, 20733, 11, "get_Css6Raw")
QDEF(MP_QSTR_get_Css7Raw, 37660, 11, "get_Css7Raw")
QDEF(MP_QSTR_get_Css8Raw, 1587, 11, "get_Css8Raw")
QDEF(MP_QSTR_get_Css9Raw, 35410, 11, "get_Css9Raw")
QDEF(MP_QSTR_get_CssCalVecX, 20041, 14, "get_CssCalVecX")
QDEF(MP_QSTR_get_CssCalVecY, 20040, 14, "get_CssCalVecY")
QDEF(MP_QSTR_get_CssCalVecZ, 20043, 14, "get_CssCalVecZ")
QDEF(MP_QSTR_get_CssIsValid, 43779, 14, "get_CssIsValid")
QDEF(MP_QSTR_get_CssR, 56861, 8, "get_CssR")
QDEF(MP_QSTR_get_CurrentExecutionPoint, 14171, 25, "get_CurrentExecutionPoint")
QDEF(MP_QSTR_get_DataRemain, 58176, 14, "get_DataRemain")
QDEF(MP_QSTR_get_DeployMag0, 57980, 14, "get_DeployMag0")
QDEF(MP_QSTR_get_DeployMag1, 57981, 14, "get_DeployMag1")
QDEF(MP_QSTR_get_Eclipse, 37417, 11, "get_Eclipse")
QDEF(MP_QSTR_get_EkfQ, 24885, 8, "get_EkfQ")
QDEF(MP_QSTR_get_EkfUseCss, 19268, 13, "get_EkfUseCss")
QDEF(MP_QSTR_get_EkfUseFss, 13697, 13, "get_EkfUseFss")
QDEF(MP_QSTR_get_EkfUseHss, 33039, 13, "get_EkfUseHss")
QDEF(MP_QSTR_get_EkfUseStr, 35378, 13, "get_EkfUseStr")
QDEF(MP_QSTR_get_EraseError, 58708, 14, "get_EraseError")
QDEF(MP_QSTR_get_ErrorCode, 35129, 13, "get_ErrorCode")
QDEF(MP_QSTR_get_ErrorFlags, 22859, 14, "get_ErrorFlags")
QDEF(MP_QSTR_get_EstGyrTorqueX, 17234, 17, "get_EstGyrTorqueX")
QDEF(MP_QSTR_get_EstGyrTorqueY, 17235, 17, "get_EstGyrTorqueY")
QDEF(MP_QSTR_get_EstGyrTorqueZ, 17232, 17, "get_EstGyrTorqueZ")
QDEF(MP_QSTR_get_EstGyroBiasX, 56364, 16, "get_EstGyroBiasX")
QDEF(MP_QSTR_get_EstGyroBiasY, 56365, 16, "get_EstGyroBiasY")
QDEF(MP_QSTR_get_EstGyroBiasZ, 56366, 16, "get_EstGyroBiasZ")
QDEF(MP_QSTR_get_EstInnovX, 40198, 13, "get_EstInnovX")
QDEF(MP_QSTR_get_EstInnovY, 40199, 13, "get_EstInnovY")
QDEF(MP_QSTR_get_EstInnovZ, 40196, 13, "get_EstInnovZ")
QDEF(MP_QSTR_get_EstModeActive, 29729, 17, "get_EstModeActive")
QDEF(MP_QSTR_get_EstModeBackup, 58627, 17, "get_EstModeBackup")
QDEF(MP_QSTR_get_EstModeBackupDefault, 58664, 24, "get_EstModeBackupDefault")
QDEF(MP_QSTR_get_EstModeMain, 49030, 15, "get_EstModeMain")
QDEF(MP_QSTR_get_EstModeMainDefault, 23309, 22, "get_EstModeMainDefault")
QDEF(MP_QSTR_get_EstQuatQ0, 58590, 13, "get_EstQuatQ0")
QDEF(MP_QSTR_get_EstQuatQ1, 58591, 13, "get_EstQuatQ1")
QDEF(MP_QSTR_get_EstQuatQ2, 58588, 13, "get_EstQuatQ2")
QDEF(MP_QSTR_get_EstQuatQ3, 58589, 13, "get_EstQuatQ3")
QDEF(MP_QSTR_get_EstRateIrcX, 4300, 15, "get_EstRateIrcX")
QDEF(MP_QSTR_get_EstRateIrcY, 4301, 15, "get_EstRateIrcY")
QDEF(MP_QSTR_get_EstRateIrcZ, 4302, 15, "get_EstRateIrcZ")
QDEF(MP_QSTR_get_EstRateOrcX, 1930, 15, "get_EstRateOrcX")
QDEF(MP_QSTR_get_EstRateOrcY, 1931, 15, "get_EstRateOrcY")
QDEF(MP_QSTR_get_EstRateOrcZ, 1928, 15, "get_EstRateOrcZ")
QDEF(MP_QSTR_get_EstRpyPitch, 20883, 15, "get_EstRpyPitch")
QDEF(MP_QSTR_get_EstRpyRoll, 35912, 14, "get_EstRpyRoll")
QDEF(MP_QSTR_get_EstRpyYaw, 42170, 13, "get_EstRpyYaw")
QDEF(MP_QSTR_get_EstStdDevQ0, 2299, 15, "get_EstStdDevQ0")
QDEF(MP_QSTR_get_EstStdDevQ1, 2298, 15, "get_EstStdDevQ1")
QDEF(MP_QSTR_get_EstStdDevQ2, 2297, 15, "get_EstStdDevQ2")
QDEF(MP_QSTR_get_EstStdDevRateX, 51136, 18, "get_EstStdDevRateX")
QDEF(MP_QSTR_get_EstStdDevRateY, 51137, 18, "get_EstStdDevRateY")
QDEF(MP_QSTR_get_EstStdDevRateZ, 51138, 18, "get_EstStdDevRateZ")
QDEF(MP_QSTR_get_EventLogSvc, 28770, 15, "get_EventLogSvc")
QDEF(MP_QSTR_get_ExecTimeControllers, 34093, 23, "get_ExecTimeControllers")
QDEF(MP_QSTR_get_ExecTimeEstimators, 8991, 22, "get_ExecTimeEstimators")
QDEF(MP_QSTR_get_ExecTimeHealth, 25470, 18, "get_ExecTimeHealth")
QDEF(MP_QSTR_get_ExecTimeLoopSync, 37113, 20, "get_ExecTimeLoopSync")
QDEF(MP_QSTR_get_ExecTimeModels, 56894, 18, "get_ExecTimeModels")
QDEF(MP_QSTR_get_ExecTimeNodeSync, 14213, 20, "get_ExecTimeNodeSync")
QDEF(MP_QSTR_get_ExecTimeSensorCal, 15482, 21, "get_ExecTimeSensorCal")
QDEF(MP_QSTR_get_ExecTimeSensorComms, 6603, 23, "get_ExecTimeSensorComms")
QDEF(MP_QSTR_get_ExecTimeTlmLog, 47475, 18, "get_ExecTimeTlmLog")
QDEF(MP_QSTR_get_ExecTimeWheelComms, 49326, 22, "get_ExecTimeWheelComms")
QDEF(MP_QSTR_get_Expected0AbstractType, 49434, 25, "get_Expected0AbstractType")
QDEF(MP_QSTR_get_Expected0NodeType, 23994, 21, "get_Expected0NodeType")
QDEF(MP_QSTR_get_Expected0SerialInt, 4881, 22, "get_Expected0SerialInt")
QDEF(MP_QSTR_get_Expected10AbstractType, 61643, 26, "get_Expected10AbstractType")
QDEF(MP_QSTR_get_Expected10NodeType, 9003, 22, "get_Expected10NodeType")
QDEF(MP_QSTR_get_Expected10SerialInt, 34912, 23, "get_Expected10SerialInt")
QDEF(MP_QSTR_get_Expected11AbstractType, 56714, 26, "get_Expected11AbstractType")
QDEF(MP_QSTR_get_Expected11NodeType, 16938, 22, "get_Expected11NodeType")
QDEF(MP_QSTR_get_Expected11SerialInt, 2433, 23, "get_Expected11SerialInt")
QDEF(MP_QSTR_get_Expected1AbstractType, 54363, 25, "get_Expected1AbstractType")
QDEF(MP_QSTR_get_Expected1NodeType, 16059, 21, "get_Expected1NodeType")
QDEF(MP_QSTR_get_Expected1SerialInt, 37360, 22, "get_Expected1SerialInt")
QDEF(MP_QSTR_get_Expected2AbstractType, 53656, 25, "get_Expected2AbstractType")
QDEF(MP_QSTR_get_Expected2NodeType, 56376, 21, "get_Expected2NodeType")
QDEF(MP_QSTR_get_Expected2SerialInt, 16851, 22, "get_Expected2SerialInt")
QDEF(MP_QSTR_get_Expected3AbstractType, 8409, 25, "get_Expected3AbstractType")
QDEF(MP_QSTR_get_Expected3NodeType, 48441, 21, "get_Expected3NodeType")
QDEF(MP_QSTR_get_Expected3SerialInt, 49586, 22, "get_Expected3SerialInt")
QDEF(MP_QSTR_get_Expected4AbstractType, 49182, 25, "get_Expected4AbstractType")
QDEF(MP_QSTR_get_Expected4NodeType, 31934, 21, "get_Expected4NodeType")
QDEF(MP_QSTR_get_Expected4SerialInt, 4757, 22, "get_Expected4SerialInt")
QDEF(MP_QSTR_get_Expected5AbstractType, 54111, 25, "get_Expected5AbstractType")
QDEF(MP_QSTR_get_Expected5NodeType, 23999, 21, "get_Expected5NodeType")
QDEF(MP_QSTR_get_Expected5SerialInt, 37236, 22, "get_Expected5SerialInt")
QDEF(MP_QSTR_get_Expected6AbstractType, 53404, 25, "get_Expected6AbstractType")
QDEF(MP_QSTR_get_Expected6NodeType, 64316, 21, "get_Expected6NodeType")
QDEF(MP_QSTR_get_Expected6SerialInt, 16727, 22, "get_Expected6SerialInt")
QDEF(MP_QSTR_get_Expected7AbstractType, 8157, 25, "get_Expected7AbstractType")
QDEF(MP_QSTR_get_Expected7NodeType, 56381, 21, "get_Expected7NodeType")
QDEF(MP_QSTR_get_Expected7SerialInt, 49462, 22, "get_Expected7SerialInt")
QDEF(MP_QSTR_get_Expected8AbstractType, 51474, 25, "get_Expected8AbstractType")
QDEF(MP_QSTR_get_Expected8NodeType, 8114, 21, "get_Expected8NodeType")
QDEF(MP_QSTR_get_Expected8SerialInt, 38425, 22, "get_Expected8SerialInt")
QDEF(MP_QSTR_get_Expected9AbstractType, 56403, 25, "get_Expected9AbstractType")
QDEF(MP_QSTR_get_Expected9NodeType, 179, 21, "get_Expected9NodeType")
QDEF(MP_QSTR_get_Expected9SerialInt, 5368, 22, "get_Expected9SerialInt")
QDEF(MP_QSTR_get_ExpectedMatchError, 60569, 22, "get_ExpectedMatchError")
QDEF(MP_QSTR_get_ExtGyro0CalRateX, 54882, 20, "get_ExtGyro0CalRateX")
QDEF(MP_QSTR_get_ExtGyro0CalRateY, 54883, 20, "get_ExtGyro0CalRateY")
QDEF(MP_QSTR_get_ExtGyro0CalRateZ, 54880, 20, "get_ExtGyro0CalRateZ")
QDEF(MP_QSTR_get_ExtGyro0IsValid, 65274, 19, "get_ExtGyro0IsValid")
QDEF(MP_QSTR_get_ExtGyro0Power, 55401, 17, "get_ExtGyro0Power")
QDEF(MP_QSTR_get_ExtGyro0State, 37217, 17, "get_ExtGyro0State")
QDEF(MP_QSTR_get_ExtGyro1CalRateX, 1763, 20, "get_ExtGyro1CalRateX")
QDEF(MP_QSTR_get_ExtGyro1CalRateY, 1762, 20, "get_ExtGyro1CalRateY")
QDEF(MP_QSTR_get_ExtGyro1CalRateZ, 1761, 20, "get_ExtGyro1CalRateZ")
QDEF(MP_QSTR_get_ExtGyro1IsValid, 40987, 19, "get_ExtGyro1IsValid")
QDEF(MP_QSTR_get_ExtGyro1Power, 44936, 17, "get_ExtGyro1Power")
QDEF(MP_QSTR_get_ExtGyro1State, 12288, 17, "get_ExtGyro1State")
QDEF(MP_QSTR_get_ExtSensor0Float0, 33315, 20, "get_ExtSensor0Float0")
QDEF(MP_QSTR_get_ExtSensor0Float1, 33314, 20, "get_ExtSensor0Float1")
QDEF(MP_QSTR_get_ExtSensor0Float2, 33313, 20, "get_ExtSensor0Float2")
QDEF(MP_QSTR_get_ExtSensor0Float3, 33312, 20, "get_ExtSensor0Float3")
QDEF(MP_QSTR_get_ExtSensor0Float4, 33319, 20, "get_ExtSensor0Float4")
QDEF(MP_QSTR_get_ExtSensor0Float5, 33318, 20, "get_ExtSensor0Float5")
QDEF(MP_QSTR_get_ExtSensor0IsValid, 8015, 21, "get_ExtSensor0IsValid")
QDEF(MP_QSTR_get_ExtSensor0Power, 1500, 19, "get_ExtSensor0Power")
QDEF(MP_QSTR_get_ExtSensor0State, 25940, 19, "get_ExtSensor0State")
QDEF(MP_QSTR_get_ExtSensor1Float0, 13730, 20, "get_ExtSensor1Float0")
QDEF(MP_QSTR_get_ExtSensor1Float1, 13731, 20, "get_ExtSensor1Float1")
QDEF(MP_QSTR_get_ExtSensor1Float2, 13728, 20, "get_ExtSensor1Float2")
QDEF(MP_QSTR_get_ExtSensor1Float3, 13729, 20, "get_ExtSensor1Float3")
QDEF(MP_QSTR_get_ExtSensor1Float4, 13734, 20, "get_ExtSensor1Float4")
QDEF(MP_QSTR_get_ExtSensor1Float5, 13735, 20, "get_ExtSensor1Float5")
QDEF(MP_QSTR_get_ExtSensor1IsValid, 30766, 21, "get_ExtSensor1IsValid")
QDEF(MP_QSTR_get_ExtSensor1Power, 36029, 19, "get_ExtSensor1Power")
QDEF(MP_QSTR_get_ExtSensor1State, 9397, 19, "get_ExtSensor1State")
QDEF(MP_QSTR_get_File, 57002, 8, "get_File")
QDEF(MP_QSTR_get_FileCrcError, 19264, 16, "get_FileCrcError")
QDEF(MP_QSTR_get_FileEmptyError, 56263, 18, "get_FileEmptyError")
QDEF(MP_QSTR_get_FileError, 39890, 13, "get_FileError")
QDEF(MP_QSTR_get_FileFullError, 54401, 17, "get_FileFullError")
QDEF(MP_QSTR_get_FileHandle, 29376, 14, "get_FileHandle")
QDEF(MP_QSTR_get_FileInvalidError, 47715, 20, "get_FileInvalidError")
QDEF(MP_QSTR_get_FileMetaError, 45039, 17, "get_FileMetaError")
QDEF(MP_QSTR_get_FileOpenReadError, 41908, 21, "get_FileOpenReadError")
QDEF(MP_QSTR_get_FileOpenWriteError, 16411, 22, "get_FileOpenWriteError")
QDEF(MP_QSTR_get_FileReadError, 17600, 17, "get_FileReadError")
QDEF(MP_QSTR_get_FileSize, 39535, 12, "get_FileSize")
QDEF(MP_QSTR_get_FileSizeError, 22263, 17, "get_FileSizeError")
QDEF(MP_QSTR_get_FileWriteError, 39023, 18, "get_FileWriteError")
QDEF(MP_QSTR_get_FirmwareMajorVersion, 46876, 24, "get_FirmwareMajorVersion")
QDEF(MP_QSTR_get_FirmwareMinorVersion, 31632, 24, "get_FirmwareMinorVersion")
QDEF(MP_QSTR_get_FirmwarePatchVersion, 15337, 24, "get_FirmwarePatchVersion")
QDEF(MP_QSTR_get_First, 52182, 9, "get_First")
QDEF(MP_QSTR_get_FlashCurrent, 10837, 16, "get_FlashCurrent")
QDEF(MP_QSTR_get_FmcStage, 1472, 12, "get_FmcStage")
QDEF(MP_QSTR_get_ForcePort, 40488, 13, "get_ForcePort")
QDEF(MP_QSTR_get_FpgaCurrent1v5, 48743, 18, "get_FpgaCurrent1v5")
QDEF(MP_QSTR_get_FramCurrent, 34045, 15, "get_FramCurrent")
QDEF(MP_QSTR_get_FramFsSvc, 48775, 13, "get_FramFsSvc")
QDEF(MP_QSTR_get_FrameSizeError, 14860, 18, "get_FrameSizeError")
QDEF(MP_QSTR_get_Fss0Alpha, 19790, 13, "get_Fss0Alpha")
QDEF(MP_QSTR_get_Fss0Beta, 19240, 12, "get_Fss0Beta")
QDEF(MP_QSTR_get_Fss0CalVecX, 54620, 15, "get_Fss0CalVecX")
QDEF(MP_QSTR_get_Fss0CalVecY, 54621, 15, "get_Fss0CalVecY")
QDEF(MP_QSTR_get_Fss0CalVecZ, 54622, 15, "get_Fss0CalVecZ")
QDEF(MP_QSTR_get_Fss0CaptureResult, 39607, 21, "get_Fss0CaptureResult")
QDEF(MP_QSTR_get_Fss0CurrentCam, 62204, 18, "get_Fss0CurrentCam")
QDEF(MP_QSTR_get_Fss0CurrentSram, 52062, 19, "get_Fss0CurrentSram")
QDEF(MP_QSTR_get_Fss0DetectionResult, 28156, 23, "get_Fss0DetectionResult")
QDEF(MP_QSTR_get_Fss0IsBest, 27008, 14, "get_Fss0IsBest")
QDEF(MP_QSTR_get_Fss0IsValid, 13590, 15, "get_Fss0IsValid")
QDEF(MP_QSTR_get_Fss0McuCurrent, 31208, 18, "get_Fss0McuCurrent")
QDEF(MP_QSTR_get_Fss0McuTemp, 33069, 15, "get_Fss0McuTemp")
QDEF(MP_QSTR_get_Fss0McuVoltage, 43715, 18, "get_Fss0McuVoltage")
QDEF(MP_QSTR_get_Fss0OvercurrentCam, 1330, 22, "get_Fss0OvercurrentCam")
QDEF(MP_QSTR_get_Fss0OvercurrentSram, 5712, 23, "get_Fss0OvercurrentSram")
QDEF(MP_QSTR_get_Fss0Power, 50117, 13, "get_Fss0Power")
QDEF(MP_QSTR_get_Fss0RawCenX, 45774, 15, "get_Fss0RawCenX")
QDEF(MP_QSTR_get_Fss0RawCenY, 45775, 15, "get_Fss0RawCenY")
QDEF(MP_QSTR_get_Fss0State, 49357, 13, "get_Fss0State")
QDEF(MP_QSTR_get_Fss1Alpha, 21871, 13, "get_Fss1Alpha")
QDEF(MP_QSTR_get_Fss1Beta, 29673, 12, "get_Fss1Beta")
QDEF(MP_QSTR_get_Fss1CalVecX, 39485, 15, "get_Fss1CalVecX")
QDEF(MP_QSTR_get_Fss1CalVecY, 39484, 15, "get_Fss1CalVecY")
QDEF(MP_QSTR_get_Fss1CalVecZ, 39487, 15, "get_Fss1CalVecZ")
QDEF(MP_QSTR_get_Fss1CaptureResult, 57942, 21, "get_Fss1CaptureResult")
QDEF(MP_QSTR_get_Fss1CurrentCam, 61053, 18, "get_Fss1CurrentCam")
QDEF(MP_QSTR_get_Fss1CurrentSram, 11839, 19, "get_Fss1CurrentSram")
QDEF(MP_QSTR_get_Fss1DetectionResult, 10141, 23, "get_Fss1DetectionResult")
QDEF(MP_QSTR_get_Fss1IsBest, 38401, 14, "get_Fss1IsBest")
QDEF(MP_QSTR_get_Fss1IsValid, 64055, 15, "get_Fss1IsValid")
QDEF(MP_QSTR_get_Fss1McuCurrent, 38505, 18, "get_Fss1McuCurrent")
QDEF(MP_QSTR_get_Fss1McuTemp, 1356, 15, "get_Fss1McuTemp")
QDEF(MP_QSTR_get_Fss1McuVoltage, 36738, 18, "get_Fss1McuVoltage")
QDEF(MP_QSTR_get_Fss1OvercurrentCam, 32691, 22, "get_Fss1OvercurrentCam")
QDEF(MP_QSTR_get_Fss1OvercurrentSram, 63793, 23, "get_Fss1OvercurrentSram")
QDEF(MP_QSTR_get_Fss1Power, 39780, 13, "get_Fss1Power")
QDEF(MP_QSTR_get_Fss1RawCenX, 34479, 15, "get_Fss1RawCenX")
QDEF(MP_QSTR_get_Fss1RawCenY, 34478, 15, "get_Fss1RawCenY")
QDEF(MP_QSTR_get_Fss1State, 57836, 13, "get_Fss1State")
QDEF(MP_QSTR_get_Fss2Alpha, 39564, 13, "get_Fss2Alpha")
QDEF(MP_QSTR_get_Fss2Beta, 11178, 12, "get_Fss2Beta")
QDEF(MP_QSTR_get_Fss2CalVecX, 27806, 15, "get_Fss2CalVecX")
QDEF(MP_QSTR_get_Fss2CalVecY, 27807, 15, "get_Fss2CalVecY")
QDEF(MP_QSTR_get_Fss2CalVecZ, 27804, 15, "get_Fss2CalVecZ")
QDEF(MP_QSTR_get_Fss2CaptureResult, 51829, 21, "get_Fss2CaptureResult")
QDEF(MP_QSTR_get_Fss2CurrentCam, 10750, 18, "get_Fss2CurrentCam")
QDEF(MP_QSTR_get_Fss2CurrentSram, 53532, 19, "get_Fss2CurrentSram")
QDEF(MP_QSTR_get_Fss2DetectionResult, 8894, 23, "get_Fss2DetectionResult")
QDEF(MP_QSTR_get_Fss2IsBest, 61570, 14, "get_Fss2IsBest")
QDEF(MP_QSTR_get_Fss2IsValid, 35796, 15, "get_Fss2IsValid")
QDEF(MP_QSTR_get_Fss2McuCurrent, 8682, 18, "get_Fss2McuCurrent")
QDEF(MP_QSTR_get_Fss2McuTemp, 14831, 15, "get_Fss2McuTemp")
QDEF(MP_QSTR_get_Fss2McuVoltage, 961, 18, "get_Fss2McuVoltage")
QDEF(MP_QSTR_get_Fss2OvercurrentCam, 6832, 22, "get_Fss2OvercurrentCam")
QDEF(MP_QSTR_get_Fss2OvercurrentSram, 60434, 23, "get_Fss2OvercurrentSram")
QDEF(MP_QSTR_get_Fss2Power, 12679, 13, "get_Fss2Power")
QDEF(MP_QSTR_get_Fss2RawCenX, 51980, 15, "get_Fss2RawCenX")
QDEF(MP_QSTR_get_Fss2RawCenY, 51981, 15, "get_Fss2RawCenY")
QDEF(MP_QSTR_get_Fss2State, 28687, 13, "get_Fss2State")
QDEF(MP_QSTR_get_Fss3Alpha, 41645, 13, "get_Fss3Alpha")
QDEF(MP_QSTR_get_Fss3Beta, 21611, 12, "get_Fss3Beta")
QDEF(MP_QSTR_get_Fss3CalVecX, 61823, 15, "get_Fss3CalVecX")
QDEF(MP_QSTR_get_Fss3CalVecY, 61822, 15, "get_Fss3CalVecY")
QDEF(MP_QSTR_get_Fss3CalVecZ, 61821, 15, "get_Fss3CalVecZ")
QDEF(MP_QSTR_get_Fss3CaptureResult, 20756, 21, "get_Fss3CaptureResult")
QDEF(MP_QSTR_get_Fss3CurrentCam, 18047, 18, "get_Fss3CurrentCam")
QDEF(MP_QSTR_get_Fss3CurrentSram, 30205, 19, "get_Fss3CurrentSram")
QDEF(MP_QSTR_get_Fss3DetectionResult, 40799, 23, "get_Fss3DetectionResult")
QDEF(MP_QSTR_get_Fss3IsBest, 7427, 14, "get_Fss3IsBest")
QDEF(MP_QSTR_get_Fss3IsValid, 20725, 15, "get_Fss3IsValid")
QDEF(MP_QSTR_get_Fss3McuCurrent, 56683, 18, "get_Fss3McuCurrent")
QDEF(MP_QSTR_get_Fss3McuTemp, 65038, 15, "get_Fss3McuTemp")
QDEF(MP_QSTR_get_Fss3McuVoltage, 1920, 18, "get_Fss3McuVoltage")
QDEF(MP_QSTR_get_Fss3OvercurrentCam, 46641, 22, "get_Fss3OvercurrentCam")
QDEF(MP_QSTR_get_Fss3OvercurrentSram, 4339, 23, "get_Fss3OvercurrentSram")
QDEF(MP_QSTR_get_Fss3Power, 2342, 13, "get_Fss3Power")
QDEF(MP_QSTR_get_Fss3RawCenX, 24301, 15, "get_Fss3RawCenX")
QDEF(MP_QSTR_get_Fss3RawCenY, 24300, 15, "get_Fss3RawCenY")
QDEF(MP_QSTR_get_Fss3State, 37166, 13, "get_Fss3State")
QDEF(MP_QSTR_get_FssR, 10296, 8, "get_FssR")
QDEF(MP_QSTR_get_GlobalErrorCode, 6546, 19, "get_GlobalErrorCode")
QDEF(MP_QSTR_get_GnssIsNew, 33507, 13, "get_GnssIsNew")
QDEF(MP_QSTR_get_GnssIsValid, 65097, 15, "get_GnssIsValid")
QDEF(MP_QSTR_get_GnssLock, 25262, 12, "get_GnssLock")
QDEF(MP_QSTR_get_GnssPPSDetected, 56688, 19, "get_GnssPPSDetected")
QDEF(MP_QSTR_get_GnssSatPosEcefX, 21650, 19, "get_GnssSatPosEcefX")
QDEF(MP_QSTR_get_GnssSatPosEcefY, 21651, 19, "get_GnssSatPosEcefY")
QDEF(MP_QSTR_get_GnssSatPosEcefZ, 21648, 19, "get_GnssSatPosEcefZ")
QDEF(MP_QSTR_get_GnssSatPosX, 3927, 15, "get_GnssSatPosX")
QDEF(MP_QSTR_get_GnssSatPosY, 3926, 15, "get_GnssSatPosY")
QDEF(MP_QSTR_get_GnssSatPosZ, 3925, 15, "get_GnssSatPosZ")
QDEF(MP_QSTR_get_GnssSatVelEcefX, 17377, 19, "get_GnssSatVelEcefX")
QDEF(MP_QSTR_get_GnssSatVelEcefY, 17376, 19, "get_GnssSatVelEcefY")
QDEF(MP_QSTR_get_GnssSatVelEcefZ, 17379, 19, "get_GnssSatVelEcefZ")
QDEF(MP_QSTR_get_GnssSatVelX, 57124, 15, "get_GnssSatVelX")
QDEF(MP_QSTR_get_GnssSatVelY, 57125, 15, "get_GnssSatVelY")
QDEF(MP_QSTR_get_GnssSatVelZ, 57126, 15, "get_GnssSatVelZ")
QDEF(MP_QSTR_get_GnssTimeNs, 62989, 14, "get_GnssTimeNs")
QDEF(MP_QSTR_get_GnssTimeSeconds, 30259, 19, "get_GnssTimeSeconds")
QDEF(MP_QSTR_get_GnssValidData, 13475, 17, "get_GnssValidData")
QDEF(MP_QSTR_get_GpsWeek, 14260, 11, "get_GpsWeek")
QDEF(MP_QSTR_get_Gyr0AuxControlLoopErrUfors1, 10382, 31, "get_Gyr0AuxControlLoopErrUfors1")
QDEF(MP_QSTR_get_Gyr0AuxControlLoopErrUfors2, 10381, 31, "get_Gyr0AuxControlLoopErrUfors2")
QDEF(MP_QSTR_get_Gyr0AuxControlLoopErrUfors3, 10380, 31, "get_Gyr0AuxControlLoopErrUfors3")
QDEF(MP_QSTR_get_Gyr0Current1, 22696, 16, "get_Gyr0Current1")
QDEF(MP_QSTR_get_Gyr0Current2, 22699, 16, "get_Gyr0Current2")
QDEF(MP_QSTR_get_Gyr0Current3, 22698, 16, "get_Gyr0Current3")
QDEF(MP_QSTR_get_Gyr0HardBitErrUfors1, 46649, 24, "get_Gyr0HardBitErrUfors1")
QDEF(MP_QSTR_get_Gyr0HardBitErrUfors2, 46650, 24, "get_Gyr0HardBitErrUfors2")
QDEF(MP_QSTR_get_Gyr0HardBitErrUfors3, 46651, 24, "get_Gyr0HardBitErrUfors3")
QDEF(MP_QSTR_get_Gyr0McuCurrent, 49314, 18, "get_Gyr0McuCurrent")
QDEF(MP_QSTR_get_Gyr0McuTemp, 28455, 15, "get_Gyr0McuTemp")
QDEF(MP_QSTR_get_Gyr0McuVoltage, 8585, 18, "get_Gyr0McuVoltage")
QDEF(MP_QSTR_get_Gyr0MeasRangeErrUfors1, 49436, 26, "get_Gyr0MeasRangeErrUfors1")
QDEF(MP_QSTR_get_Gyr0MeasRangeErrUfors2, 49439, 26, "get_Gyr0MeasRangeErrUfors2")
QDEF(MP_QSTR_get_Gyr0MeasRangeErrUfors3, 49438, 26, "get_Gyr0MeasRangeErrUfors3")
QDEF(MP_QSTR_get_Gyr0NogoUfors1, 59413, 18, "get_Gyr0NogoUfors1")
QDEF(MP_QSTR_get_Gyr0NogoUfors2, 59414, 18, "get_Gyr0NogoUfors2")
QDEF(MP_QSTR_get_Gyr0NogoUfors3, 59415, 18, "get_Gyr0NogoUfors3")
QDEF(MP_QSTR_get_Gyr0Overcurrent1, 39142, 20, "get_Gyr0Overcurrent1")
QDEF(MP_QSTR_get_Gyr0Overcurrent2, 39141, 20, "get_Gyr0Overcurrent2")
QDEF(MP_QSTR_get_Gyr0Overcurrent3, 39140, 20, "get_Gyr0Overcurrent3")
QDEF(MP_QSTR_get_Gyr0RateUfors1, 9982, 18, "get_Gyr0RateUfors1")
QDEF(MP_QSTR_get_Gyr0RateUfors2, 9981, 18, "get_Gyr0RateUfors2")
QDEF(MP_QSTR_get_Gyr0RateUfors3, 9980, 18, "get_Gyr0RateUfors3")
QDEF(MP_QSTR_get_Gyr0RstAckUfors1, 13920, 20, "get_Gyr0RstAckUfors1")
QDEF(MP_QSTR_get_Gyr0RstAckUfors2, 13923, 20, "get_Gyr0RstAckUfors2")
QDEF(MP_QSTR_get_Gyr0RstAckUfors3, 13922, 20, "get_Gyr0RstAckUfors3")
QDEF(MP_QSTR_get_Gyr0TempWarnUfors1, 14362, 22, "get_Gyr0TempWarnUfors1")
QDEF(MP_QSTR_get_Gyr0TempWarnUfors2, 14361, 22, "get_Gyr0TempWarnUfors2")
QDEF(MP_QSTR_get_Gyr0TempWarnUfors3, 14360, 22, "get_Gyr0TempWarnUfors3")
QDEF(MP_QSTR_get_Gyr0UnknwnCmdUfors1, 54097, 23, "get_Gyr0UnknwnCmdUfors1")
QDEF(MP_QSTR_get_Gyr0UnknwnCmdUfors2, 54098, 23, "get_Gyr0UnknwnCmdUfors2")
QDEF(MP_QSTR_get_Gyr0UnknwnCmdUfors3, 54099, 23, "get_Gyr0UnknwnCmdUfors3")
QDEF(MP_QSTR_get_Gyr1AuxControlLoopErrUfors1, 42031, 31, "get_Gyr1AuxControlLoopErrUfors1")
QDEF(MP_QSTR_get_Gyr1AuxControlLoopErrUfors2, 42028, 31, "get_Gyr1AuxControlLoopErrUfors2")
QDEF(MP_QSTR_get_Gyr1AuxControlLoopErrUfors3, 42029, 31, "get_Gyr1AuxControlLoopErrUfors3")
QDEF(MP_QSTR_get_Gyr1Current1, 5993, 16, "get_Gyr1Current1")
QDEF(MP_QSTR_get_Gyr1Current2, 5994, 16, "get_Gyr1Current2")
QDEF(MP_QSTR_get_Gyr1Current3, 5995, 16, "get_Gyr1Current3")
QDEF(MP_QSTR_get_Gyr1HardBitErrUfors1, 46648, 24, "get_Gyr1HardBitErrUfors1")
QDEF(MP_QSTR_get_Gyr1HardBitErrUfors2, 46651, 24, "get_Gyr1HardBitErrUfors2")
QDEF(MP_QSTR_get_Gyr1HardBitErrUfors3, 46650, 24, "get_Gyr1HardBitErrUfors3")
QDEF(MP_QSTR_get_Gyr1McuCurrent, 7203, 18, "get_Gyr1McuCurrent")
QDEF(MP_QSTR_get_Gyr1McuTemp, 37446, 15, "get_Gyr1McuTemp")
QDEF(MP_QSTR_get_Gyr1McuVoltage, 17992, 18, "get_Gyr1McuVoltage")
QDEF(MP_QSTR_get_Gyr1MeasRangeErrUfors1, 21597, 26, "get_Gyr1MeasRangeErrUfors1")
QDEF(MP_QSTR_get_Gyr1MeasRangeErrUfors2, 21598, 26, "get_Gyr1MeasRangeErrUfors2")
QDEF(MP_QSTR_get_Gyr1MeasRangeErrUfors3, 21599, 26, "get_Gyr1MeasRangeErrUfors3")
QDEF(MP_QSTR_get_Gyr1NogoUfors1, 10900, 18, "get_Gyr1NogoUfors1")
QDEF(MP_QSTR_get_Gyr1NogoUfors2, 10903, 18, "get_Gyr1NogoUfors2")
QDEF(MP_QSTR_get_Gyr1NogoUfors3, 10902, 18, "get_Gyr1NogoUfors3")
QDEF(MP_QSTR_get_Gyr1Overcurrent1, 39079, 20, "get_Gyr1Overcurrent1")
QDEF(MP_QSTR_get_Gyr1Overcurrent2, 39076, 20, "get_Gyr1Overcurrent2")
QDEF(MP_QSTR_get_Gyr1Overcurrent3, 39077, 20, "get_Gyr1Overcurrent3")
QDEF(MP_QSTR_get_Gyr1RateUfors1, 16831, 18, "get_Gyr1RateUfors1")
QDEF(MP_QSTR_get_Gyr1RateUfors2, 16828, 18, "get_Gyr1RateUfors2")
QDEF(MP_QSTR_get_Gyr1RateUfors3, 16829, 18, "get_Gyr1RateUfors3")
QDEF(MP_QSTR_get_Gyr1RstAckUfors1, 19937, 20, "get_Gyr1RstAckUfors1")
QDEF(MP_QSTR_get_Gyr1RstAckUfors2, 19938, 20, "get_Gyr1RstAckUfors2")
QDEF(MP_QSTR_get_Gyr1RstAckUfors3, 19939, 20, "get_Gyr1RstAckUfors3")
QDEF(MP_QSTR_get_Gyr1TempWarnUfors1, 17819, 22, "get_Gyr1TempWarnUfors1")
QDEF(MP_QSTR_get_Gyr1TempWarnUfors2, 17816, 22, "get_Gyr1TempWarnUfors2")
QDEF(MP_QSTR_get_Gyr1TempWarnUfors3, 17817, 22, "get_Gyr1TempWarnUfors3")
QDEF(MP_QSTR_get_Gyr1UnknwnCmdUfors1, 55472, 23, "get_Gyr1UnknwnCmdUfors1")
QDEF(MP_QSTR_get_Gyr1UnknwnCmdUfors2, 55475, 23, "get_Gyr1UnknwnCmdUfors2")
QDEF(MP_QSTR_get_Gyr1UnknwnCmdUfors3, 55474, 23, "get_Gyr1UnknwnCmdUfors3")
QDEF(MP_QSTR_get_Gyro0CalRateX, 56907, 17, "get_Gyro0CalRateX")
QDEF(MP_QSTR_get_Gyro0CalRateY, 56906, 17, "get_Gyro0CalRateY")
QDEF(MP_QSTR_get_Gyro0CalRateZ, 56905, 17, "get_Gyro0CalRateZ")
QDEF(MP_QSTR_get_Gyro0IsValid, 50675, 16, "get_Gyro0IsValid")
QDEF(MP_QSTR_get_Gyro0Power, 46624, 14, "get_Gyro0Power")
QDEF(MP_QSTR_get_Gyro0RawRateX, 13249, 17, "get_Gyro0RawRateX")
QDEF(MP_QSTR_get_Gyro0RawRateY, 13248, 17, "get_Gyro0RawRateY")
QDEF(MP_QSTR_get_Gyro0RawRateZ, 13251, 17, "get_Gyro0RawRateZ")
QDEF(MP_QSTR_get_Gyro0State, 56488, 14, "get_Gyro0State")
QDEF(MP_QSTR_get_Gyro1CalRateX, 8010, 17, "get_Gyro1CalRateX")
QDEF(MP_QSTR_get_Gyro1CalRateY, 8011, 17, "get_Gyro1CalRateY")
QDEF(MP_QSTR_get_Gyro1CalRateZ, 8008, 17, "get_Gyro1CalRateZ")
QDEF(MP_QSTR_get_Gyro1IsValid, 33490, 16, "get_Gyro1IsValid")
QDEF(MP_QSTR_get_Gyro1Power, 32129, 14, "get_Gyro1Power")
QDEF(MP_QSTR_get_Gyro1RawRateX, 19264, 17, "get_Gyro1RawRateX")
QDEF(MP_QSTR_get_Gyro1RawRateY, 19265, 17, "get_Gyro1RawRateY")
QDEF(MP_QSTR_get_Gyro1RawRateZ, 19266, 17, "get_Gyro1RawRateZ")
QDEF(MP_QSTR_get_Gyro1State, 56457, 14, "get_Gyro1State")
QDEF(MP_QSTR_get_GyroCurrent, 45894, 15, "get_GyroCurrent")
QDEF(MP_QSTR_get_GyroOverVoltage, 31363, 19, "get_GyroOverVoltage")
QDEF(MP_QSTR_get_GyroUnderVoltage, 48101, 20, "get_GyroUnderVoltage")
QDEF(MP_QSTR_get_H_ref, 41450, 9, "get_H_ref")
QDEF(MP_QSTR_get_HilSyncOk, 56354, 13, "get_HilSyncOk")
QDEF(MP_QSTR_get_Hss0CalVecX, 65362, 15, "get_Hss0CalVecX")
QDEF(MP_QSTR_get_Hss0CalVecY, 65363, 15, "get_Hss0CalVecY")
QDEF(MP_QSTR_get_Hss0CalVecZ, 65360, 15, "get_Hss0CalVecZ")
QDEF(MP_QSTR_get_Hss0CaptureResult, 25145, 21, "get_Hss0CaptureResult")
QDEF(MP_QSTR_get_Hss0DetectionResult, 37234, 23, "get_Hss0DetectionResult")
QDEF(MP_QSTR_get_Hss0DetectorCurrent, 41543, 23, "get_Hss0DetectorCurrent")
QDEF(MP_QSTR_get_Hss0DetectorTemp, 23458, 20, "get_Hss0DetectorTemp")
QDEF(MP_QSTR_get_Hss0IsValid, 8088, 15, "get_Hss0IsValid")
QDEF(MP_QSTR_get_Hss0McuCurrent, 23718, 18, "get_Hss0McuCurrent")
QDEF(MP_QSTR_get_Hss0McuTemp, 19363, 15, "get_Hss0McuTemp")
QDEF(MP_QSTR_get_Hss0McuVoltage, 56973, 18, "get_Hss0McuVoltage")
QDEF(MP_QSTR_get_Hss0Power, 21067, 13, "get_Hss0Power")
QDEF(MP_QSTR_get_Hss0RawElev, 27530, 15, "get_Hss0RawElev")
QDEF(MP_QSTR_get_Hss0RawRot, 33689, 14, "get_Hss0RawRot")
QDEF(MP_QSTR_get_Hss0State, 11459, 13, "get_Hss0State")
QDEF(MP_QSTR_get_Hss1CalVecX, 41779, 15, "get_Hss1CalVecX")
QDEF(MP_QSTR_get_Hss1CalVecY, 41778, 15, "get_Hss1CalVecY")
QDEF(MP_QSTR_get_Hss1CalVecZ, 41777, 15, "get_Hss1CalVecZ")
QDEF(MP_QSTR_get_Hss1CaptureResult, 10712, 21, "get_Hss1CaptureResult")
QDEF(MP_QSTR_get_Hss1DetectionResult, 60435, 23, "get_Hss1DetectionResult")
QDEF(MP_QSTR_get_Hss1DetectorCurrent, 51430, 23, "get_Hss1DetectorCurrent")
QDEF(MP_QSTR_get_Hss1DetectorTemp, 65123, 20, "get_Hss1DetectorTemp")
QDEF(MP_QSTR_get_Hss1IsValid, 25273, 15, "get_Hss1IsValid")
QDEF(MP_QSTR_get_Hss1McuCurrent, 47143, 18, "get_Hss1McuCurrent")
QDEF(MP_QSTR_get_Hss1McuTemp, 28354, 15, "get_Hss1McuTemp")
QDEF(MP_QSTR_get_Hss1McuVoltage, 844, 18, "get_Hss1McuVoltage")
QDEF(MP_QSTR_get_Hss1Power, 35562, 13, "get_Hss1Power")
QDEF(MP_QSTR_get_Hss1RawElev, 26347, 15, "get_Hss1RawElev")
QDEF(MP_QSTR_get_Hss1RawRot, 18264, 14, "get_Hss1RawRot")
QDEF(MP_QSTR_get_Hss1State, 11490, 13, "get_Hss1State")
QDEF(MP_QSTR_get_HssR, 3958, 8, "get_HssR")
QDEF(MP_QSTR_get_Hx, 15356, 6, "get_Hx")
QDEF(MP_QSTR_get_Hy, 15357, 6, "get_Hy")
QDEF(MP_QSTR_get_Hy_bias, 59963, 11, "get_Hy_bias")
QDEF(MP_QSTR_get_Hz, 15358, 6, "get_Hz")
QDEF(MP_QSTR_get_ImgLogSvc, 37517, 13, "get_ImgLogSvc")
QDEF(MP_QSTR_get_ImuSvc, 34011, 10, "get_ImuSvc")
QDEF(MP_QSTR_get_InvalidNodeError, 43941, 20, "get_InvalidNodeError")
QDEF(MP_QSTR_get_IsValid, 48320, 11, "get_IsValid")
QDEF(MP_QSTR_get_Ixx, 46853, 7, "get_Ixx")
QDEF(MP_QSTR_get_Ixy, 46852, 7, "get_Ixy")
QDEF(MP_QSTR_get_Ixz, 46855, 7, "get_Ixz")
QDEF(MP_QSTR_get_Iyy, 46885, 7, "get_Iyy")
QDEF(MP_QSTR_get_Iyz, 46886, 7, "get_Iyz")
QDEF(MP_QSTR_get_Izz, 47045, 7, "get_Izz")
QDEF(MP_QSTR_get_Kd, 15235, 6, "get_Kd")
QDEF(MP_QSTR_get_Kd1, 43986, 7, "get_Kd1")
QDEF(MP_QSTR_get_Kd2, 43985, 7, "get_Kd2")
QDEF(MP_QSTR_get_Kd3, 43984, 7, "get_Kd3")
QDEF(MP_QSTR_get_Kdecl, 41129, 9, "get_Kdecl")
QDEF(MP_QSTR_get_Kdf, 43909, 7, "get_Kdf")
QDEF(MP_QSTR_get_Kdsun, 56043, 9, "get_Kdsun")
QDEF(MP_QSTR_get_Kh, 15247, 6, "get_Kh")
QDEF(MP_QSTR_get_Ki3, 44413, 7, "get_Ki3")
QDEF(MP_QSTR_get_Kn, 15241, 6, "get_Kn")
QDEF(MP_QSTR_get_Kp1, 44614, 7, "get_Kp1")
QDEF(MP_QSTR_get_Kp2, 44613, 7, "get_Kp2")
QDEF(MP_QSTR_get_Kp3, 44612, 7, "get_Kp3")
QDEF(MP_QSTR_get_Kq, 15254, 6, "get_Kq")
QDEF(MP_QSTR_get_Kqx, 44590, 7, "get_Kqx")
QDEF(MP_QSTR_get_Kqy, 44591, 7, "get_Kqy")
QDEF(MP_QSTR_get_Kqz, 44588, 7, "get_Kqz")
QDEF(MP_QSTR_get_Ks, 15252, 6, "get_Ks")
QDEF(MP_QSTR_get_Last, 42566, 8, "get_Last")
QDEF(MP_QSTR_get_LoopHasStarted, 39947, 18, "get_LoopHasStarted")
QDEF(MP_QSTR_get_LoopRtcOffset, 3256, 17, "get_LoopRtcOffset")
QDEF(MP_QSTR_get_Mag0BurnCurrent, 43701, 19, "get_Mag0BurnCurrent")
QDEF(MP_QSTR_get_Mag0BurnOverCurrent, 36955, 23, "get_Mag0BurnOverCurrent")
QDEF(MP_QSTR_get_Mag0BurnPinState, 27804, 20, "get_Mag0BurnPinState")
QDEF(MP_QSTR_get_Mag0BurnUnderCurrent, 41181, 24, "get_Mag0BurnUnderCurrent")
QDEF(MP_QSTR_get_Mag0CalVecX, 24209, 15, "get_Mag0CalVecX")
QDEF(MP_QSTR_get_Mag0CalVecY, 24208, 15, "get_Mag0CalVecY")
QDEF(MP_QSTR_get_Mag0CalVecZ, 24211, 15, "get_Mag0CalVecZ")
QDEF(MP_QSTR_get_Mag0DeployPinState, 58300, 22, "get_Mag0DeployPinState")
QDEF(MP_QSTR_get_Mag0DeployTimeout, 2887, 21, "get_Mag0DeployTimeout")
QDEF(MP_QSTR_get_Mag0IsBest, 40045, 14, "get_Mag0IsBest")
QDEF(MP_QSTR_get_Mag0IsValid, 11099, 15, "get_Mag0IsValid")
QDEF(MP_QSTR_get_Mag0McuCurrent, 33477, 18, "get_Mag0McuCurrent")
QDEF(MP_QSTR_get_Mag0McuTemp, 48224, 15, "get_Mag0McuTemp")
QDEF(MP_QSTR_get_Mag0McuVoltage, 48366, 18, "get_Mag0McuVoltage")
QDEF(MP_QSTR_get_Mag0Power, 22728, 13, "get_Mag0Power")
QDEF(MP_QSTR_get_Mag0PrimaryTemp, 64183, 19, "get_Mag0PrimaryTemp")
QDEF(MP_QSTR_get_Mag0RawVecX, 37851, 15, "get_Mag0RawVecX")
QDEF(MP_QSTR_get_Mag0RawVecY, 37850, 15, "get_Mag0RawVecY")
QDEF(MP_QSTR_get_Mag0RawVecZ, 37849, 15, "get_Mag0RawVecZ")
QDEF(MP_QSTR_get_Mag0RedTemp, 18408, 15, "get_Mag0RedTemp")
QDEF(MP_QSTR_get_Mag0SensingElement, 64418, 22, "get_Mag0SensingElement")
QDEF(MP_QSTR_get_Mag0State, 38976, 13, "get_Mag0State")
QDEF(MP_QSTR_get_Mag1BurnCurrent, 28116, 19, "get_Mag1BurnCurrent")
QDEF(MP_QSTR_get_Mag1BurnOverCurrent, 37946, 23, "get_Mag1BurnOverCurrent")
QDEF(MP_QSTR_get_Mag1BurnPinState, 64285, 20, "get_Mag1BurnPinState")
QDEF(MP_QSTR_get_Mag1BurnUnderCurrent, 20060, 24, "get_Mag1BurnUnderCurrent")
QDEF(MP_QSTR_get_Mag1CalVecX, 39600, 15, "get_Mag1CalVecX")
QDEF(MP_QSTR_get_Mag1CalVecY, 39601, 15, "get_Mag1CalVecY")
QDEF(MP_QSTR_get_Mag1CalVecZ, 39602, 15, "get_Mag1CalVecZ")
QDEF(MP_QSTR_get_Mag1DeployPinState, 57085, 22, "get_Mag1DeployPinState")
QDEF(MP_QSTR_get_Mag1DeployTimeout, 40870, 21, "get_Mag1DeployTimeout")
QDEF(MP_QSTR_get_Mag1IsBest, 52716, 14, "get_Mag1IsBest")
QDEF(MP_QSTR_get_Mag1IsValid, 33850, 15, "get_Mag1IsValid")
QDEF(MP_QSTR_get_Mag1McuCurrent, 30148, 18, "get_Mag1McuCurrent")
QDEF(MP_QSTR_get_Mag1McuTemp, 47041, 15, "get_Mag1McuTemp")
QDEF(MP_QSTR_get_Mag1McuVoltage, 1967, 18, "get_Mag1McuVoltage")
QDEF(MP_QSTR_get_Mag1Power, 57257, 13, "get_Mag1Power")
QDEF(MP_QSTR_get_Mag1PrimaryTemp, 38294, 19, "get_Mag1PrimaryTemp")
QDEF(MP_QSTR_get_Mag1RawVecX, 38778, 15, "get_Mag1RawVecX")
QDEF(MP_QSTR_get_Mag1RawVecY, 38779, 15, "get_Mag1RawVecY")
QDEF(MP_QSTR_get_Mag1RawVecZ, 38776, 15, "get_Mag1RawVecZ")
QDEF(MP_QSTR_get_Mag1RedTemp, 35785, 15, "get_Mag1RedTemp")
QDEF(MP_QSTR_get_Mag1SensingElement, 10083, 22, "get_Mag1SensingElement")
QDEF(MP_QSTR_get_Mag1State, 22433, 13, "get_Mag1State")
QDEF(MP_QSTR_get_MagConTimeout, 45502, 17, "get_MagConTimeout")
QDEF(MP_QSTR_get_MagR, 2133, 8, "get_MagR")
QDEF(MP_QSTR_get_MasterSvc, 44950, 13, "get_MasterSvc")
QDEF(MP_QSTR_get_MaxPosErr, 62481, 13, "get_MaxPosErr")
QDEF(MP_QSTR_get_MaxTimeBetween, 8231, 18, "get_MaxTimeBetween")
QDEF(MP_QSTR_get_McuCurrent, 638, 14, "get_McuCurrent")
QDEF(MP_QSTR_get_McuTemp, 10491, 11, "get_McuTemp")
QDEF(MP_QSTR_get_McuVoltage, 35157, 14, "get_McuVoltage")
QDEF(MP_QSTR_get_MetaData, 10401, 12, "get_MetaData")
QDEF(MP_QSTR_get_ModelHorRhoAngle, 290, 20, "get_ModelHorRhoAngle")
QDEF(MP_QSTR_get_ModelHorXoEastAngle, 9283, 23, "get_ModelHorXoEastAngle")
QDEF(MP_QSTR_get_ModelHorYiEastAngle, 18564, 23, "get_ModelHorYiEastAngle")
QDEF(MP_QSTR_get_ModelMagOrcX, 50254, 16, "get_ModelMagOrcX")
QDEF(MP_QSTR_get_ModelMagOrcY, 50255, 16, "get_ModelMagOrcY")
QDEF(MP_QSTR_get_ModelMagOrcZ, 50252, 16, "get_ModelMagOrcZ")
QDEF(MP_QSTR_get_ModelSunBetaAngle, 43416, 21, "get_ModelSunBetaAngle")
QDEF(MP_QSTR_get_ModelSunOrcX, 12941, 16, "get_ModelSunOrcX")
QDEF(MP_QSTR_get_ModelSunOrcY, 12940, 16, "get_ModelSunOrcY")
QDEF(MP_QSTR_get_ModelSunOrcZ, 12943, 16, "get_ModelSunOrcZ")
QDEF(MP_QSTR_get_MountCss0, 47442, 13, "get_MountCss0")
QDEF(MP_QSTR_get_MountCss1, 47443, 13, "get_MountCss1")
QDEF(MP_QSTR_get_MountCss2, 47440, 13, "get_MountCss2")
QDEF(MP_QSTR_get_MountCss3, 47441, 13, "get_MountCss3")
QDEF(MP_QSTR_get_MountCss4, 47446, 13, "get_MountCss4")
QDEF(MP_QSTR_get_MountCss5, 47447, 13, "get_MountCss5")
QDEF(MP_QSTR_get_MountCss6, 47444, 13, "get_MountCss6")
QDEF(MP_QSTR_get_MountCss7, 47445, 13, "get_MountCss7")
QDEF(MP_QSTR_get_MountCss8, 47450, 13, "get_MountCss8")
QDEF(MP_QSTR_get_MountCss9, 47451, 13, "get_MountCss9")
QDEF(MP_QSTR_get_MountExtGyr0Axis1, 51174, 21, "get_MountExtGyr0Axis1")
QDEF(MP_QSTR_get_MountExtGyr0Axis2, 51173, 21, "get_MountExtGyr0Axis2")
QDEF(MP_QSTR_get_MountExtGyr0Axis3, 51172, 21, "get_MountExtGyr0Axis3")
QDEF(MP_QSTR_get_MountExtGyr1Axis1, 51015, 21, "get_MountExtGyr1Axis1")
QDEF(MP_QSTR_get_MountExtGyr1Axis2, 51012, 21, "get_MountExtGyr1Axis2")
QDEF(MP_QSTR_get_MountExtGyr1Axis3, 51013, 21, "get_MountExtGyr1Axis3")
QDEF(MP_QSTR_get_MountExtSensor0Alpha, 57114, 24, "get_MountExtSensor0Alpha")
QDEF(MP_QSTR_get_MountExtSensor0Beta, 10236, 23, "get_MountExtSensor0Beta")
QDEF(MP_QSTR_get_MountExtSensor0Gamma, 19529, 24, "get_MountExtSensor0Gamma")
QDEF(MP_QSTR_get_MountExtSensor1Alpha, 59195, 24, "get_MountExtSensor1Alpha")
QDEF(MP_QSTR_get_MountExtSensor1Beta, 3773, 23, "get_MountExtSensor1Beta")
QDEF(MP_QSTR_get_MountExtSensor1Gamma, 21736, 24, "get_MountExtSensor1Gamma")
QDEF(MP_QSTR_get_MountFss0Alpha, 15491, 18, "get_MountFss0Alpha")
QDEF(MP_QSTR_get_MountFss0Beta, 36677, 17, "get_MountFss0Beta")
QDEF(MP_QSTR_get_MountFss0Gamma, 53328, 18, "get_MountFss0Gamma")
QDEF(MP_QSTR_get_MountFss1Alpha, 46818, 18, "get_MountFss1Alpha")
QDEF(MP_QSTR_get_MountFss1Beta, 38660, 17, "get_MountFss1Beta")
QDEF(MP_QSTR_get_MountFss1Gamma, 59441, 18, "get_MountFss1Gamma")
QDEF(MP_QSTR_get_MountFss2Alpha, 19649, 18, "get_MountFss2Alpha")
QDEF(MP_QSTR_get_MountFss2Beta, 53447, 17, "get_MountFss2Beta")
QDEF(MP_QSTR_get_MountFss2Gamma, 146, 18, "get_MountFss2Gamma")
QDEF(MP_QSTR_get_MountFss3Alpha, 1056, 18, "get_MountFss3Alpha")
QDEF(MP_QSTR_get_MountFss3Beta, 22150, 17, "get_MountFss3Beta")
QDEF(MP_QSTR_get_MountFss3Gamma, 55667, 18, "get_MountFss3Gamma")
QDEF(MP_QSTR_get_MountHss0Alpha, 53133, 18, "get_MountHss0Alpha")
QDEF(MP_QSTR_get_MountHss0Beta, 7051, 17, "get_MountHss0Beta")
QDEF(MP_QSTR_get_MountHss0Gamma, 9822, 18, "get_MountHss0Gamma")
QDEF(MP_QSTR_get_MountHss1Alpha, 18924, 18, "get_MountHss1Alpha")
QDEF(MP_QSTR_get_MountHss1Beta, 25930, 17, "get_MountHss1Beta")
QDEF(MP_QSTR_get_MountHss1Gamma, 7487, 18, "get_MountHss1Gamma")
QDEF(MP_QSTR_get_MountMag0Alpha, 1678, 18, "get_MountMag0Alpha")
QDEF(MP_QSTR_get_MountMag0Beta, 12264, 17, "get_MountMag0Beta")
QDEF(MP_QSTR_get_MountMag0Gamma, 15325, 18, "get_MountMag0Gamma")
QDEF(MP_QSTR_get_MountMag1Alpha, 3759, 18, "get_MountMag1Alpha")
QDEF(MP_QSTR_get_MountMag1Beta, 5801, 17, "get_MountMag1Beta")
QDEF(MP_QSTR_get_MountMag1Gamma, 17532, 18, "get_MountMag1Gamma")
QDEF(MP_QSTR_get_MountMtq0, 16537, 13, "get_MountMtq0")
QDEF(MP_QSTR_get_MountMtq1, 16536, 13, "get_MountMtq1")
QDEF(MP_QSTR_get_MountMtq2, 16539, 13, "get_MountMtq2")
QDEF(MP_QSTR_get_MountRwl0, 36568, 13, "get_MountRwl0")
QDEF(MP_QSTR_get_MountRwl1, 36569, 13, "get_MountRwl1")
QDEF(MP_QSTR_get_MountRwl2, 36570, 13, "get_MountRwl2")
QDEF(MP_QSTR_get_MountRwl3, 36571, 13, "get_MountRwl3")
QDEF(MP_QSTR_get_MountRwlPyrAlpha, 28455, 20, "get_MountRwlPyrAlpha")
QDEF(MP_QSTR_get_MountRwlPyrBeta, 1057, 19, "get_MountRwlPyrBeta")
QDEF(MP_QSTR_get_MountRwlPyrGamma, 8948, 20, "get_MountRwlPyrGamma")
QDEF(MP_QSTR_get_MountStackX, 42135, 15, "get_MountStackX")
QDEF(MP_QSTR_get_MountStackY, 42134, 15, "get_MountStackY")
QDEF(MP_QSTR_get_MountStackZ, 42133, 15, "get_MountStackZ")
QDEF(MP_QSTR_get_MountStr0Alpha, 46448, 18, "get_MountStr0Alpha")
QDEF(MP_QSTR_get_MountStr0Beta, 11606, 17, "get_MountStr0Beta")
QDEF(MP_QSTR_get_MountStr0Gamma, 16035, 18, "get_MountStr0Gamma")
QDEF(MP_QSTR_get_MountStr1Alpha, 15121, 18, "get_MountStr1Alpha")
QDEF(MP_QSTR_get_MountStr1Beta, 58263, 17, "get_MountStr1Beta")
QDEF(MP_QSTR_get_MountStr1Gamma, 18370, 18, "get_MountStr1Gamma")
QDEF(MP_QSTR_get_Mtq0CmdDip, 28643, 14, "get_Mtq0CmdDip")
QDEF(MP_QSTR_get_Mtq0CmdOnTime, 50954, 17, "get_Mtq0CmdOnTime")
QDEF(MP_QSTR_get_Mtq0CmdTorque, 64086, 17, "get_Mtq0CmdTorque")
QDEF(MP_QSTR_get_Mtq0Mmax, 40269, 12, "get_Mtq0Mmax")
QDEF(MP_QSTR_get_Mtq0OnTimeCmd, 1546, 17, "get_Mtq0OnTimeCmd")
QDEF(MP_QSTR_get_Mtq1CmdDip, 31650, 14, "get_Mtq1CmdDip")
QDEF(MP_QSTR_get_Mtq1CmdOnTime, 10475, 17, "get_Mtq1CmdOnTime")
QDEF(MP_QSTR_get_Mtq1CmdTorque, 15095, 17, "get_Mtq1CmdTorque")
QDEF(MP_QSTR_get_Mtq1Mmax, 36108, 12, "get_Mtq1Mmax")
QDEF(MP_QSTR_get_Mtq1OnTimeCmd, 30187, 17, "get_Mtq1OnTimeCmd")
QDEF(MP_QSTR_get_Mtq1Polarity, 34705, 16, "get_Mtq1Polarity")
QDEF(MP_QSTR_get_Mtq1TotalCurrentAverageNeg, 16689, 30, "get_Mtq1TotalCurrentAverageNeg")
QDEF(MP_QSTR_get_Mtq1TotalCurrentAveragePos, 14065, 30, "get_Mtq1TotalCurrentAveragePos")
QDEF(MP_QSTR_get_Mtq1TotalCurrentPeakNeg, 46861, 27, "get_Mtq1TotalCurrentPeakNeg")
QDEF(MP_QSTR_get_Mtq1TotalCurrentPeakPos, 53965, 27, "get_Mtq1TotalCurrentPeakPos")
QDEF(MP_QSTR_get_Mtq2CmdDip, 14177, 14, "get_Mtq2CmdDip")
QDEF(MP_QSTR_get_Mtq2CmdOnTime, 9800, 17, "get_Mtq2CmdOnTime")
QDEF(MP_QSTR_get_Mtq2CmdTorque, 34964, 17, "get_Mtq2CmdTorque")
QDEF(MP_QSTR_get_Mtq2Mmax, 44623, 12, "get_Mtq2Mmax")
QDEF(MP_QSTR_get_Mtq2OnTimeCmd, 42824, 17, "get_Mtq2OnTimeCmd")
QDEF(MP_QSTR_get_Mtq2Polarity, 61394, 16, "get_Mtq2Polarity")
QDEF(MP_QSTR_get_Mtq2TotalCurrentAverageNeg, 45874, 30, "get_Mtq2TotalCurrentAverageNeg")
QDEF(MP_QSTR_get_Mtq2TotalCurrentAveragePos, 47474, 30, "get_Mtq2TotalCurrentAveragePos")
QDEF(MP_QSTR_get_Mtq2TotalCurrentPeakNeg, 53230, 27, "get_Mtq2TotalCurrentPeakNeg")
QDEF(MP_QSTR_get_Mtq2TotalCurrentPeakPos, 55854, 27, "get_Mtq2TotalCurrentPeakPos")
QDEF(MP_QSTR_get_Mtq3Polarity, 34579, 16, "get_Mtq3Polarity")
QDEF(MP_QSTR_get_Mtq3TotalCurrentAverageNeg, 18483, 30, "get_Mtq3TotalCurrentAverageNeg")
QDEF(MP_QSTR_get_Mtq3TotalCurrentAveragePos, 11635, 30, "get_Mtq3TotalCurrentAveragePos")
QDEF(MP_QSTR_get_Mtq3TotalCurrentPeakNeg, 52431, 27, "get_Mtq3TotalCurrentPeakNeg")
QDEF(MP_QSTR_get_Mtq3TotalCurrentPeakPos, 63503, 27, "get_Mtq3TotalCurrentPeakPos")
QDEF(MP_QSTR_get_MtqFfac, 23494, 11, "get_MtqFfac")
QDEF(MP_QSTR_get_NDel, 4207, 8, "get_NDel")
QDEF(MP_QSTR_get_NavSource, 31656, 13, "get_NavSource")
QDEF(MP_QSTR_get_Node, 46508, 8, "get_Node")
QDEF(MP_QSTR_get_NodeCommsError, 26347, 18, "get_NodeCommsError")
QDEF(MP_QSTR_get_NodeExistError, 48263, 18, "get_NodeExistError")
QDEF(MP_QSTR_get_NodeExpectError, 17291, 19, "get_NodeExpectError")
QDEF(MP_QSTR_get_NodeType, 25620, 12, "get_NodeType")
QDEF(MP_QSTR_get_NodeTypeSlot0, 6016, 17, "get_NodeTypeSlot0")
QDEF(MP_QSTR_get_NodeTypeSlot1, 6017, 17, "get_NodeTypeSlot1")
QDEF(MP_QSTR_get_NodeTypeSlot2, 6018, 17, "get_NodeTypeSlot2")
QDEF(MP_QSTR_get_NodeTypeSlot3, 6019, 17, "get_NodeTypeSlot3")
QDEF(MP_QSTR_get_NodeUsedError, 15059, 17, "get_NodeUsedError")
QDEF(MP_QSTR_get_NoneDiscoveredError, 21996, 23, "get_NoneDiscoveredError")
QDEF(MP_QSTR_get_NoneExpected, 63864, 16, "get_NoneExpected")
QDEF(MP_QSTR_get_NutDeps, 34049, 11, "get_NutDeps")
QDEF(MP_QSTR_get_NutDpsi, 53869, 11, "get_NutDpsi")
QDEF(MP_QSTR_get_Offset1, 63728, 11, "get_Offset1")
QDEF(MP_QSTR_get_Offset2, 63731, 11, "get_Offset2")
QDEF(MP_QSTR_get_Offset3, 63730, 11, "get_Offset3")
QDEF(MP_QSTR_get_OnTimeMax, 17836, 13, "get_OnTimeMax")
QDEF(MP_QSTR_get_OnTimeMin, 18098, 13, "get_OnTimeMin")
QDEF(MP_QSTR_get_OpCode, 39646, 10, "get_OpCode")
QDEF(MP_QSTR_get_OpState, 9764, 11, "get_OpState")
QDEF(MP_QSTR_get_OpStateDefault, 61167, 18, "get_OpStateDefault")
QDEF(MP_QSTR_get_OrbModeActive, 23708, 17, "get_OrbModeActive")
QDEF(MP_QSTR_get_OrbitAP, 57119, 11, "get_OrbitAP")
QDEF(MP_QSTR_get_OrbitBstar, 21560, 14, "get_OrbitBstar")
QDEF(MP_QSTR_get_OrbitEccen, 55136, 14, "get_OrbitEccen")
QDEF(MP_QSTR_get_OrbitEpoch, 5919, 14, "get_OrbitEpoch")
QDEF(MP_QSTR_get_OrbitIncl, 2054, 13, "get_OrbitIncl")
QDEF(MP_QSTR_get_OrbitMA, 56706, 11, "get_OrbitMA")
QDEF(MP_QSTR_get_OrbitMM, 56718, 11, "get_OrbitMM")
QDEF(MP_QSTR_get_OrbitMode, 64557, 13, "get_OrbitMode")
QDEF(MP_QSTR_get_OrbitRaan, 32690, 13, "get_OrbitRaan")
QDEF(MP_QSTR_get_OtpSerialError, 40703, 18, "get_OtpSerialError")
QDEF(MP_QSTR_get_OwnerNodeType, 60565, 17, "get_OwnerNodeType")
QDEF(MP_QSTR_get_OwnerProgram, 55737, 16, "get_OwnerProgram")
QDEF(MP_QSTR_get_OwnerSerialInt, 15838, 18, "get_OwnerSerialInt")
QDEF(MP_QSTR_get_Port1Slot0, 22896, 14, "get_Port1Slot0")
QDEF(MP_QSTR_get_Port1Slot1, 22897, 14, "get_Port1Slot1")
QDEF(MP_QSTR_get_Port1Slot2, 22898, 14, "get_Port1Slot2")
QDEF(MP_QSTR_get_Port1Slot3, 22899, 14, "get_Port1Slot3")
QDEF(MP_QSTR_get_Port2Slot0, 14547, 14, "get_Port2Slot0")
QDEF(MP_QSTR_get_Port2Slot1, 14546, 14, "get_Port2Slot1")
QDEF(MP_QSTR_get_Port2Slot2, 14545, 14, "get_Port2Slot2")
QDEF(MP_QSTR_get_Port2Slot3, 14544, 14, "get_Port2Slot3")
QDEF(MP_QSTR_get_Port3Slot0, 47794, 14, "get_Port3Slot0")
QDEF(MP_QSTR_get_Port3Slot1, 47795, 14, "get_Port3Slot1")
QDEF(MP_QSTR_get_Port3Slot2, 47792, 14, "get_Port3Slot2")
QDEF(MP_QSTR_get_Port3Slot3, 47793, 14, "get_Port3Slot3")
QDEF(MP_QSTR_get_Port4Slot0, 14613, 14, "get_Port4Slot0")
QDEF(MP_QSTR_get_Port4Slot1, 14612, 14, "get_Port4Slot1")
QDEF(MP_QSTR_get_Port4Slot2, 14615, 14, "get_Port4Slot2")
QDEF(MP_QSTR_get_Port4Slot3, 14614, 14, "get_Port4Slot3")
QDEF(MP_QSTR_get_PortDiscoveryError, 36359, 22, "get_PortDiscoveryError")
QDEF(MP_QSTR_get_PortValidationError, 5126, 23, "get_PortValidationError")
QDEF(MP_QSTR_get_Program, 26136, 11, "get_Program")
QDEF(MP_QSTR_get_PyrHnom, 48243, 11, "get_PyrHnom")
QDEF(MP_QSTR_get_PyrTiltAngle, 57939, 16, "get_PyrTiltAngle")
QDEF(MP_QSTR_get_QuatErrQ0, 41113, 13, "get_QuatErrQ0")
QDEF(MP_QSTR_get_QuatErrQ1, 41112, 13, "get_QuatErrQ1")
QDEF(MP_QSTR_get_QuatErrQ2, 41115, 13, "get_QuatErrQ2")
QDEF(MP_QSTR_get_ReadError, 27622, 13, "get_ReadError")
QDEF(MP_QSTR_get_RedGyroCurrent, 13077, 18, "get_RedGyroCurrent")
QDEF(MP_QSTR_get_RedGyroOverVoltage, 26512, 22, "get_RedGyroOverVoltage")
QDEF(MP_QSTR_get_RedGyroUnderVoltage, 13142, 23, "get_RedGyroUnderVoltage")
QDEF(MP_QSTR_get_ResetReason, 44925, 15, "get_ResetReason")
QDEF(MP_QSTR_get_RkfQ, 48066, 8, "get_RkfQ")
QDEF(MP_QSTR_get_RollLimit, 7492, 13, "get_RollLimit")
QDEF(MP_QSTR_get_RpyCmdPitch, 42683, 15, "get_RpyCmdPitch")
QDEF(MP_QSTR_get_RpyCmdRoll, 34592, 14, "get_RpyCmdRoll")
QDEF(MP_QSTR_get_RpyCmdYaw, 39122, 13, "get_RpyCmdYaw")
QDEF(MP_QSTR_get_RpyErrPitch, 55476, 15, "get_RpyErrPitch")
QDEF(MP_QSTR_get_RpyErrRoll, 63631, 14, "get_RpyErrRoll")
QDEF(MP_QSTR_get_RpyErrYaw, 7581, 13, "get_RpyErrYaw")
QDEF(MP_QSTR_get_Rs485Current, 10589, 16, "get_Rs485Current")
QDEF(MP_QSTR_get_RtcDriftNs, 23705, 14, "get_RtcDriftNs")
QDEF(MP_QSTR_get_RtcTimeNs, 9121, 13, "get_RtcTimeNs")
QDEF(MP_QSTR_get_RtcTimeSeconds, 48159, 18, "get_RtcTimeSeconds")
QDEF(MP_QSTR_get_RunMode, 64422, 11, "get_RunMode")
QDEF(MP_QSTR_get_RunModeDefault, 6701, 18, "get_RunModeDefault")
QDEF(MP_QSTR_get_Rwl0ActiveFlag, 52853, 18, "get_Rwl0ActiveFlag")
QDEF(MP_QSTR_get_Rwl0BatCurrent, 59659, 18, "get_Rwl0BatCurrent")
QDEF(MP_QSTR_get_Rwl0BatVoltage, 12832, 18, "get_Rwl0BatVoltage")
QDEF(MP_QSTR_get_Rwl0CmdMom, 54384, 14, "get_Rwl0CmdMom")
QDEF(MP_QSTR_get_Rwl0CmdSpeed, 47480, 16, "get_Rwl0CmdSpeed")
QDEF(MP_QSTR_get_Rwl0CmdTorque, 46263, 17, "get_Rwl0CmdTorque")
QDEF(MP_QSTR_get_Rwl0CrcError, 51999, 16, "get_Rwl0CrcError")
QDEF(MP_QSTR_get_Rwl0CurentCtrlMode, 38884, 22, "get_Rwl0CurentCtrlMode")
QDEF(MP_QSTR_get_Rwl0Current5v, 59359, 17, "get_Rwl0Current5v")
QDEF(MP_QSTR_get_Rwl0ErrorFlag, 7841, 17, "get_Rwl0ErrorFlag")
QDEF(MP_QSTR_get_Rwl0Hmax, 29545, 12, "get_Rwl0Hmax")
QDEF(MP_QSTR_get_Rwl0IsValid, 59609, 15, "get_Rwl0IsValid")
QDEF(MP_QSTR_get_Rwl0Iw, 33451, 10, "get_Rwl0Iw")
QDEF(MP_QSTR_get_Rwl0McuCurrent, 43527, 18, "get_Rwl0McuCurrent")
QDEF(MP_QSTR_get_Rwl0McuTemp, 24034, 15, "get_Rwl0McuTemp")
QDEF(MP_QSTR_get_Rwl0McuVoltage, 5164, 18, "get_Rwl0McuVoltage")
QDEF(MP_QSTR_get_Rwl0MeasCurrent, 21062, 19, "get_Rwl0MeasCurrent")
QDEF(MP_QSTR_get_Rwl0MeasSpeed, 46856, 17, "get_Rwl0MeasSpeed")
QDEF(MP_QSTR_get_Rwl0MeasValid, 48249, 17, "get_Rwl0MeasValid")
QDEF(MP_QSTR_get_Rwl0Nmax, 40111, 12, "get_Rwl0Nmax")
QDEF(MP_QSTR_get_Rwl0Overcurrent5v, 20433, 21, "get_Rwl0Overcurrent5v")
QDEF(MP_QSTR_get_Rwl0PmuCurrent, 11444, 18, "get_Rwl0PmuCurrent")
QDEF(MP_QSTR_get_Rwl0PmuCurrentValid, 31586, 23, "get_Rwl0PmuCurrentValid")
QDEF(MP_QSTR_get_Rwl0Power, 36682, 13, "get_Rwl0Power")
QDEF(MP_QSTR_get_Rwl0PowerGood, 6057, 17, "get_Rwl0PowerGood")
QDEF(MP_QSTR_get_Rwl0SpeedCmd, 280, 16, "get_Rwl0SpeedCmd")
QDEF(MP_QSTR_get_Rwl0SpeedCtrlMode, 20472, 21, "get_Rwl0SpeedCtrlMode")
QDEF(MP_QSTR_get_Rwl0SpeedMeas, 27912, 17, "get_Rwl0SpeedMeas")
QDEF(MP_QSTR_get_Rwl0State, 37442, 13, "get_Rwl0State")
QDEF(MP_QSTR_get_Rwl0TargetValue, 54063, 19, "get_Rwl0TargetValue")
QDEF(MP_QSTR_get_Rwl0Temp, 23929, 12, "get_Rwl0Temp")
QDEF(MP_QSTR_get_Rwl0TorqueCtrlMode, 47351, 22, "get_Rwl0TorqueCtrlMode")
QDEF(MP_QSTR_get_Rwl0ToutSci1Main, 55532, 20, "get_Rwl0ToutSci1Main")
QDEF(MP_QSTR_get_Rwl0WheelMode, 18341, 17, "get_Rwl0WheelMode")
QDEF(MP_QSTR_get_Rwl0WrongHlCmd, 59032, 18, "get_Rwl0WrongHlCmd")
QDEF(MP_QSTR_get_Rwl0WrongLlCmd, 59036, 18, "get_Rwl0WrongLlCmd")
QDEF(MP_QSTR_get_Rwl1ActiveFlag, 34932, 18, "get_Rwl1ActiveFlag")
QDEF(MP_QSTR_get_Rwl1BatCurrent, 37514, 18, "get_Rwl1BatCurrent")
QDEF(MP_QSTR_get_Rwl1BatVoltage, 13409, 18, "get_Rwl1BatVoltage")
QDEF(MP_QSTR_get_Rwl1CmdMom, 32561, 14, "get_Rwl1CmdMom")
QDEF(MP_QSTR_get_Rwl1CmdSpeed, 18617, 16, "get_Rwl1CmdSpeed")
QDEF(MP_QSTR_get_Rwl1CmdTorque, 38166, 17, "get_Rwl1CmdTorque")
QDEF(MP_QSTR_get_Rwl1CrcError, 11294, 16, "get_Rwl1CrcError")
QDEF(MP_QSTR_get_Rwl1CurentCtrlMode, 26725, 22, "get_Rwl1CurentCtrlMode")
QDEF(MP_QSTR_get_Rwl1Current5v, 60990, 17, "get_Rwl1Current5v")
QDEF(MP_QSTR_get_Rwl1ErrorFlag, 24320, 17, "get_Rwl1ErrorFlag")
QDEF(MP_QSTR_get_Rwl1Hmax, 14952, 12, "get_Rwl1Hmax")
QDEF(MP_QSTR_get_Rwl1IsValid, 50104, 15, "get_Rwl1IsValid")
QDEF(MP_QSTR_get_Rwl1Iw, 28202, 10, "get_Rwl1Iw")
QDEF(MP_QSTR_get_Rwl1McuCurrent, 56326, 18, "get_Rwl1McuCurrent")
QDEF(MP_QSTR_get_Rwl1McuTemp, 63555, 15, "get_Rwl1McuTemp")
QDEF(MP_QSTR_get_Rwl1McuVoltage, 40685, 18, "get_Rwl1McuVoltage")
QDEF(MP_QSTR_get_Rwl1MeasCurrent, 42279, 19, "get_Rwl1MeasCurrent")
QDEF(MP_QSTR_get_Rwl1MeasSpeed, 52841, 17, "get_Rwl1MeasSpeed")
QDEF(MP_QSTR_get_Rwl1MeasValid, 62232, 17, "get_Rwl1MeasValid")
QDEF(MP_QSTR_get_Rwl1Nmax, 8878, 12, "get_Rwl1Nmax")
QDEF(MP_QSTR_get_Rwl1Overcurrent5v, 38704, 21, "get_Rwl1Overcurrent5v")
QDEF(MP_QSTR_get_Rwl1PmuCurrent, 4085, 18, "get_Rwl1PmuCurrent")
QDEF(MP_QSTR_get_Rwl1PmuCurrentValid, 34499, 23, "get_Rwl1PmuCurrentValid")
QDEF(MP_QSTR_get_Rwl1Power, 30507, 13, "get_Rwl1Power")
QDEF(MP_QSTR_get_Rwl1PowerGood, 6152, 17, "get_Rwl1PowerGood")
QDEF(MP_QSTR_get_Rwl1SpeedCmd, 50841, 16, "get_Rwl1SpeedCmd")
QDEF(MP_QSTR_get_Rwl1SpeedCtrlMode, 29209, 21, "get_Rwl1SpeedCtrlMode")
QDEF(MP_QSTR_get_Rwl1SpeedMeas, 58025, 17, "get_Rwl1SpeedMeas")
QDEF(MP_QSTR_get_Rwl1State, 12451, 13, "get_Rwl1State")
QDEF(MP_QSTR_get_Rwl1TargetValue, 20814, 19, "get_Rwl1TargetValue")
QDEF(MP_QSTR_get_Rwl1Temp, 9336, 12, "get_Rwl1Temp")
QDEF(MP_QSTR_get_Rwl1TorqueCtrlMode, 31862, 22, "get_Rwl1TorqueCtrlMode")
QDEF(MP_QSTR_get_Rwl1ToutSci1Main, 61549, 20, "get_Rwl1ToutSci1Main")
QDEF(MP_QSTR_get_Rwl1WheelMode, 48388, 17, "get_Rwl1WheelMode")
QDEF(MP_QSTR_get_Rwl1WrongHlCmd, 4825, 18, "get_Rwl1WrongHlCmd")
QDEF(MP_QSTR_get_Rwl1WrongLlCmd, 4829, 18, "get_Rwl1WrongLlCmd")
QDEF(MP_QSTR_get_Rwl2ActiveFlag, 62583, 18, "get_Rwl2ActiveFlag")
QDEF(MP_QSTR_get_Rwl2BatCurrent, 49289, 18, "get_Rwl2BatCurrent")
QDEF(MP_QSTR_get_Rwl2BatVoltage, 14754, 18, "get_Rwl2BatVoltage")
QDEF(MP_QSTR_get_Rwl2CmdMom, 31602, 14, "get_Rwl2CmdMom")
QDEF(MP_QSTR_get_Rwl2CmdSpeed, 51962, 16, "get_Rwl2CmdSpeed")
QDEF(MP_QSTR_get_Rwl2CmdTorque, 1013, 17, "get_Rwl2CmdTorque")
QDEF(MP_QSTR_get_Rwl2CrcError, 51997, 16, "get_Rwl2CrcError")
QDEF(MP_QSTR_get_Rwl2CurentCtrlMode, 52582, 22, "get_Rwl2CurentCtrlMode")
QDEF(MP_QSTR_get_Rwl2Current5v, 34717, 17, "get_Rwl2Current5v")
QDEF(MP_QSTR_get_Rwl2ErrorFlag, 45027, 17, "get_Rwl2ErrorFlag")
QDEF(MP_QSTR_get_Rwl2Hmax, 25451, 12, "get_Rwl2Hmax")
QDEF(MP_QSTR_get_Rwl2IsValid, 36891, 15, "get_Rwl2IsValid")
QDEF(MP_QSTR_get_Rwl2Iw, 31401, 10, "get_Rwl2Iw")
QDEF(MP_QSTR_get_Rwl2McuCurrent, 517, 18, "get_Rwl2McuCurrent")
QDEF(MP_QSTR_get_Rwl2McuTemp, 41760, 15, "get_Rwl2McuTemp")
QDEF(MP_QSTR_get_Rwl2McuVoltage, 39982, 18, "get_Rwl2McuVoltage")
QDEF(MP_QSTR_get_Rwl2MeasCurrent, 55940, 19, "get_Rwl2MeasCurrent")
QDEF(MP_QSTR_get_Rwl2MeasSpeed, 6218, 17, "get_Rwl2MeasSpeed")
QDEF(MP_QSTR_get_Rwl2MeasValid, 23995, 17, "get_Rwl2MeasValid")
QDEF(MP_QSTR_get_Rwl2Nmax, 23341, 12, "get_Rwl2Nmax")
QDEF(MP_QSTR_get_Rwl2Overcurrent5v, 44947, 21, "get_Rwl2Overcurrent5v")
QDEF(MP_QSTR_get_Rwl2PmuCurrent, 41910, 18, "get_Rwl2PmuCurrent")
QDEF(MP_QSTR_get_Rwl2PmuCurrentValid, 57376, 23, "get_Rwl2PmuCurrentValid")
QDEF(MP_QSTR_get_Rwl2Power, 40840, 13, "get_Rwl2Power")
QDEF(MP_QSTR_get_Rwl2PowerGood, 22763, 17, "get_Rwl2PowerGood")
QDEF(MP_QSTR_get_Rwl2SpeedCmd, 40602, 16, "get_Rwl2SpeedCmd")
QDEF(MP_QSTR_get_Rwl2SpeedCtrlMode, 15546, 21, "get_Rwl2SpeedCtrlMode")
QDEF(MP_QSTR_get_Rwl2SpeedMeas, 51914, 17, "get_Rwl2SpeedMeas")
QDEF(MP_QSTR_get_Rwl2State, 8192, 13, "get_Rwl2State")
QDEF(MP_QSTR_get_Rwl2TargetValue, 23661, 19, "get_Rwl2TargetValue")
QDEF(MP_QSTR_get_Rwl2Temp, 19835, 12, "get_Rwl2Temp")
QDEF(MP_QSTR_get_Rwl2TorqueCtrlMode, 36981, 22, "get_Rwl2TorqueCtrlMode")
QDEF(MP_QSTR_get_Rwl2ToutSci1Main, 55150, 20, "get_Rwl2ToutSci1Main")
QDEF(MP_QSTR_get_Rwl2WheelMode, 46695, 17, "get_Rwl2WheelMode")
QDEF(MP_QSTR_get_Rwl2WrongHlCmd, 11546, 18, "get_Rwl2WrongHlCmd")
QDEF(MP_QSTR_get_Rwl2WrongLlCmd, 11550, 18, "get_Rwl2WrongLlCmd")
QDEF(MP_QSTR_get_Rwl3ActiveFlag, 37238, 18, "get_Rwl3ActiveFlag")
QDEF(MP_QSTR_get_Rwl3BatCurrent, 27656, 18, "get_Rwl3BatCurrent")
QDEF(MP_QSTR_get_Rwl3BatVoltage, 15843, 18, "get_Rwl3BatVoltage")
QDEF(MP_QSTR_get_Rwl3CmdMom, 26163, 14, "get_Rwl3CmdMom")
QDEF(MP_QSTR_get_Rwl3CmdSpeed, 39483, 16, "get_Rwl3CmdSpeed")
QDEF(MP_QSTR_get_Rwl3CmdTorque, 9300, 17, "get_Rwl3CmdTorque")
QDEF(MP_QSTR_get_Rwl3CrcError, 27676, 16, "get_Rwl3CrcError")
QDEF(MP_QSTR_get_Rwl3CurentCtrlMode, 743, 22, "get_Rwl3CurentCtrlMode")
QDEF(MP_QSTR_get_Rwl3Current5v, 3836, 17, "get_Rwl3Current5v")
QDEF(MP_QSTR_get_Rwl3ErrorFlag, 44866, 17, "get_Rwl3ErrorFlag")
QDEF(MP_QSTR_get_Rwl3Hmax, 44138, 12, "get_Rwl3Hmax")
QDEF(MP_QSTR_get_Rwl3IsValid, 61178, 15, "get_Rwl3IsValid")
QDEF(MP_QSTR_get_Rwl3Iw, 34600, 10, "get_Rwl3Iw")
QDEF(MP_QSTR_get_Rwl3McuCurrent, 13828, 18, "get_Rwl3McuCurrent")
QDEF(MP_QSTR_get_Rwl3McuTemp, 32641, 15, "get_Rwl3McuTemp")
QDEF(MP_QSTR_get_Rwl3McuVoltage, 10479, 18, "get_Rwl3McuVoltage")
QDEF(MP_QSTR_get_Rwl3MeasCurrent, 28517, 19, "get_Rwl3MeasCurrent")
QDEF(MP_QSTR_get_Rwl3MeasSpeed, 12459, 17, "get_Rwl3MeasSpeed")
QDEF(MP_QSTR_get_Rwl3MeasValid, 5466, 17, "get_Rwl3MeasValid")
QDEF(MP_QSTR_get_Rwl3Nmax, 25388, 12, "get_Rwl3Nmax")
QDEF(MP_QSTR_get_Rwl3Overcurrent5v, 47090, 21, "get_Rwl3Overcurrent5v")
QDEF(MP_QSTR_get_Rwl3PmuCurrent, 35063, 18, "get_Rwl3PmuCurrent")
QDEF(MP_QSTR_get_Rwl3PmuCurrentValid, 11649, 23, "get_Rwl3PmuCurrentValid")
QDEF(MP_QSTR_get_Rwl3Power, 51305, 13, "get_Rwl3Power")
QDEF(MP_QSTR_get_Rwl3PowerGood, 6730, 17, "get_Rwl3PowerGood")
QDEF(MP_QSTR_get_Rwl3SpeedCmd, 18203, 16, "get_Rwl3SpeedCmd")
QDEF(MP_QSTR_get_Rwl3SpeedCtrlMode, 25563, 21, "get_Rwl3SpeedCtrlMode")
QDEF(MP_QSTR_get_Rwl3SpeedMeas, 33643, 17, "get_Rwl3SpeedMeas")
QDEF(MP_QSTR_get_Rwl3State, 33121, 13, "get_Rwl3State")
QDEF(MP_QSTR_get_Rwl3TargetValue, 39052, 19, "get_Rwl3TargetValue")
QDEF(MP_QSTR_get_Rwl3Temp, 38522, 12, "get_Rwl3Temp")
QDEF(MP_QSTR_get_Rwl3TorqueCtrlMode, 30452, 22, "get_Rwl3TorqueCtrlMode")
QDEF(MP_QSTR_get_Rwl3ToutSci1Main, 12015, 20, "get_Rwl3ToutSci1Main")
QDEF(MP_QSTR_get_Rwl3WheelMode, 28358, 17, "get_Rwl3WheelMode")
QDEF(MP_QSTR_get_Rwl3WrongHlCmd, 23387, 18, "get_Rwl3WrongHlCmd")
QDEF(MP_QSTR_get_Rwl3WrongLlCmd, 23391, 18, "get_Rwl3WrongLlCmd")
QDEF(MP_QSTR_get_RwlFailId, 39978, 13, "get_RwlFailId")
QDEF(MP_QSTR_get_RwlIsValid, 53641, 14, "get_RwlIsValid")
QDEF(MP_QSTR_get_RwlMomVecX, 61570, 14, "get_RwlMomVecX")
QDEF(MP_QSTR_get_RwlMomVecY, 61571, 14, "get_RwlMomVecY")
QDEF(MP_QSTR_get_RwlMomVecZ, 61568, 14, "get_RwlMomVecZ")
QDEF(MP_QSTR_get_RwlScheme, 6672, 13, "get_RwlScheme")
QDEF(MP_QSTR_get_RwlTorqueVecX, 21381, 17, "get_RwlTorqueVecX")
QDEF(MP_QSTR_get_RwlTorqueVecY, 21380, 17, "get_RwlTorqueVecY")
QDEF(MP_QSTR_get_RwlTorqueVecZ, 21383, 17, "get_RwlTorqueVecZ")
QDEF(MP_QSTR_get_Sat2TgtGndOrcX, 5012, 18, "get_Sat2TgtGndOrcX")
QDEF(MP_QSTR_get_Sat2TgtGndOrcY, 5013, 18, "get_Sat2TgtGndOrcY")
QDEF(MP_QSTR_get_Sat2TgtGndOrcZ, 5014, 18, "get_Sat2TgtGndOrcZ")
QDEF(MP_QSTR_get_SatAlt, 55731, 10, "get_SatAlt")
QDEF(MP_QSTR_get_SatLatGeoc, 25149, 14, "get_SatLatGeoc")
QDEF(MP_QSTR_get_SatLatGeod, 25146, 14, "get_SatLatGeod")
QDEF(MP_QSTR_get_SatLon, 44231, 10, "get_SatLon")
QDEF(MP_QSTR_get_SatPosEciX, 57105, 14, "get_SatPosEciX")
QDEF(MP_QSTR_get_SatPosEciY, 57104, 14, "get_SatPosEciY")
QDEF(MP_QSTR_get_SatPosEciZ, 57107, 14, "get_SatPosEciZ")
QDEF(MP_QSTR_get_SatTrackBodyVecX, 9693, 20, "get_SatTrackBodyVecX")
QDEF(MP_QSTR_get_SatTrackBodyVecY, 9692, 20, "get_SatTrackBodyVecY")
QDEF(MP_QSTR_get_SatTrackBodyVecZ, 9695, 20, "get_SatTrackBodyVecZ")
QDEF(MP_QSTR_get_SatVelEciX, 40706, 14, "get_SatVelEciX")
QDEF(MP_QSTR_get_SatVelEciY, 40707, 14, "get_SatVelEciY")
QDEF(MP_QSTR_get_SatVelEciZ, 40704, 14, "get_SatVelEciZ")
QDEF(MP_QSTR_get_SelectExt, 50093, 13, "get_SelectExt")
QDEF(MP_QSTR_get_SelectFss, 48834, 13, "get_SelectFss")
QDEF(MP_QSTR_get_SelectGnss, 19277, 14, "get_SelectGnss")
QDEF(MP_QSTR_get_SelectGyro, 30119, 14, "get_SelectGyro")
QDEF(MP_QSTR_get_SelectHss, 64076, 13, "get_SelectHss")
QDEF(MP_QSTR_get_SelectMag, 58063, 13, "get_SelectMag")
QDEF(MP_QSTR_get_SelectRwl, 3917, 13, "get_SelectRwl")
QDEF(MP_QSTR_get_SelectStr, 11313, 13, "get_SelectStr")
QDEF(MP_QSTR_get_SensMatrix11, 10076, 16, "get_SensMatrix11")
QDEF(MP_QSTR_get_SensMatrix12, 10079, 16, "get_SensMatrix12")
QDEF(MP_QSTR_get_SensMatrix13, 10078, 16, "get_SensMatrix13")
QDEF(MP_QSTR_get_SensMatrix21, 10175, 16, "get_SensMatrix21")
QDEF(MP_QSTR_get_SensMatrix22, 10172, 16, "get_SensMatrix22")
QDEF(MP_QSTR_get_SensMatrix23, 10173, 16, "get_SensMatrix23")
QDEF(MP_QSTR_get_SensMatrix31, 10142, 16, "get_SensMatrix31")
QDEF(MP_QSTR_get_SensMatrix32, 10141, 16, "get_SensMatrix32")
QDEF(MP_QSTR_get_SensMatrix33, 10140, 16, "get_SensMatrix33")
QDEF(MP_QSTR_get_Sensor1AbstractType, 62003, 23, "get_Sensor1AbstractType")
QDEF(MP_QSTR_get_Sensor1AbstractTypeError, 10667, 28, "get_Sensor1AbstractTypeError")
QDEF(MP_QSTR_get_Sensor1AddrAssignError, 11585, 26, "get_Sensor1AddrAssignError")
QDEF(MP_QSTR_get_Sensor1Address, 14237, 18, "get_Sensor1Address")
QDEF(MP_QSTR_get_Sensor1CommsError, 50636, 21, "get_Sensor1CommsError")
QDEF(MP_QSTR_get_Sensor1ErrorCode, 55454, 20, "get_Sensor1ErrorCode")
QDEF(MP_QSTR_get_Sensor1NodeType, 34579, 19, "get_Sensor1NodeType")
QDEF(MP_QSTR_get_Sensor1NodeTypeMatchError, 51288, 29, "get_Sensor1NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor1SerialInt, 34968, 20, "get_Sensor1SerialInt")
QDEF(MP_QSTR_get_Sensor1SerialMatchError, 31584, 27, "get_Sensor1SerialMatchError")
QDEF(MP_QSTR_get_Sensor1SerialResolveError, 51463, 29, "get_Sensor1SerialResolveError")
QDEF(MP_QSTR_get_Sensor1UnexpectedError, 4758, 26, "get_Sensor1UnexpectedError")
QDEF(MP_QSTR_get_Sensor2AbstractType, 29040, 23, "get_Sensor2AbstractType")
QDEF(MP_QSTR_get_Sensor2AbstractTypeError, 55624, 28, "get_Sensor2AbstractTypeError")
QDEF(MP_QSTR_get_Sensor2AddrAssignError, 8098, 26, "get_Sensor2AddrAssignError")
QDEF(MP_QSTR_get_Sensor2Address, 47998, 18, "get_Sensor2Address")
QDEF(MP_QSTR_get_Sensor2CommsError, 6159, 21, "get_Sensor2CommsError")
QDEF(MP_QSTR_get_Sensor2ErrorCode, 14397, 20, "get_Sensor2ErrorCode")
QDEF(MP_QSTR_get_Sensor2NodeType, 58512, 19, "get_Sensor2NodeType")
QDEF(MP_QSTR_get_Sensor2NodeTypeMatchError, 57499, 29, "get_Sensor2NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor2SerialInt, 63099, 20, "get_Sensor2SerialInt")
QDEF(MP_QSTR_get_Sensor2SerialMatchError, 10467, 27, "get_Sensor2SerialMatchError")
QDEF(MP_QSTR_get_Sensor2SerialResolveError, 21700, 29, "get_Sensor2SerialResolveError")
QDEF(MP_QSTR_get_Sensor2UnexpectedError, 30325, 26, "get_Sensor2UnexpectedError")
QDEF(MP_QSTR_get_Sensor3AbstractType, 177, 23, "get_Sensor3AbstractType")
QDEF(MP_QSTR_get_Sensor3AbstractTypeError, 63593, 28, "get_Sensor3AbstractTypeError")
QDEF(MP_QSTR_get_Sensor3AddrAssignError, 9219, 26, "get_Sensor3AddrAssignError")
QDEF(MP_QSTR_get_Sensor3Address, 16095, 18, "get_Sensor3Address")
QDEF(MP_QSTR_get_Sensor3CommsError, 3278, 21, "get_Sensor3CommsError")
QDEF(MP_QSTR_get_Sensor3ErrorCode, 14428, 20, "get_Sensor3ErrorCode")
QDEF(MP_QSTR_get_Sensor3NodeType, 34193, 19, "get_Sensor3NodeType")
QDEF(MP_QSTR_get_Sensor3NodeTypeMatchError, 7898, 29, "get_Sensor3NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor3SerialInt, 63066, 20, "get_Sensor3SerialInt")
QDEF(MP_QSTR_get_Sensor3SerialMatchError, 6498, 27, "get_Sensor3SerialMatchError")
QDEF(MP_QSTR_get_Sensor3SerialResolveError, 65029, 29, "get_Sensor3SerialResolveError")
QDEF(MP_QSTR_get_Sensor3UnexpectedError, 35412, 26, "get_Sensor3UnexpectedError")
QDEF(MP_QSTR_get_Sensor4AbstractType, 25078, 23, "get_Sensor4AbstractType")
QDEF(MP_QSTR_get_Sensor4AbstractTypeError, 18702, 28, "get_Sensor4AbstractTypeError")
QDEF(MP_QSTR_get_Sensor4AddrAssignError, 56164, 26, "get_Sensor4AddrAssignError")
QDEF(MP_QSTR_get_Sensor4Address, 25784, 18, "get_Sensor4Address")
QDEF(MP_QSTR_get_Sensor4CommsError, 57865, 21, "get_Sensor4CommsError")
QDEF(MP_QSTR_get_Sensor4ErrorCode, 64251, 20, "get_Sensor4ErrorCode")
QDEF(MP_QSTR_get_Sensor4NodeType, 1302, 19, "get_Sensor4NodeType")
QDEF(MP_QSTR_get_Sensor4NodeTypeMatchError, 55581, 29, "get_Sensor4NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor4SerialInt, 34877, 20, "get_Sensor4SerialInt")
QDEF(MP_QSTR_get_Sensor4SerialMatchError, 59877, 27, "get_Sensor4SerialMatchError")
QDEF(MP_QSTR_get_Sensor4SerialResolveError, 53186, 29, "get_Sensor4SerialResolveError")
QDEF(MP_QSTR_get_Sensor4UnexpectedError, 61235, 26, "get_Sensor4UnexpectedError")
QDEF(MP_QSTR_get_Sensor5AbstractType, 61751, 23, "get_Sensor5AbstractType")
QDEF(MP_QSTR_get_Sensor5AbstractTypeError, 26671, 28, "get_Sensor5AbstractTypeError")
QDEF(MP_QSTR_get_Sensor5AddrAssignError, 57285, 26, "get_Sensor5AddrAssignError")
QDEF(MP_QSTR_get_Sensor5Address, 59417, 18, "get_Sensor5Address")
QDEF(MP_QSTR_get_Sensor5CommsError, 38600, 21, "get_Sensor5CommsError")
QDEF(MP_QSTR_get_Sensor5ErrorCode, 47386, 20, "get_Sensor5ErrorCode")
QDEF(MP_QSTR_get_Sensor5NodeType, 42519, 19, "get_Sensor5NodeType")
QDEF(MP_QSTR_get_Sensor5NodeTypeMatchError, 55132, 29, "get_Sensor5NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor5SerialInt, 34844, 20, "get_Sensor5SerialInt")
QDEF(MP_QSTR_get_Sensor5SerialMatchError, 39524, 27, "get_Sensor5SerialMatchError")
QDEF(MP_QSTR_get_Sensor5SerialResolveError, 14595, 29, "get_Sensor5SerialResolveError")
QDEF(MP_QSTR_get_Sensor5UnexpectedError, 786, 26, "get_Sensor5UnexpectedError")
QDEF(MP_QSTR_get_Sensor6AbstractType, 28788, 23, "get_Sensor6AbstractType")
QDEF(MP_QSTR_get_Sensor6AbstractTypeError, 6092, 28, "get_Sensor6AbstractTypeError")
QDEF(MP_QSTR_get_Sensor6AddrAssignError, 53798, 26, "get_Sensor6AddrAssignError")
QDEF(MP_QSTR_get_Sensor6Address, 27642, 18, "get_Sensor6Address")
QDEF(MP_QSTR_get_Sensor6CommsError, 59659, 21, "get_Sensor6CommsError")
QDEF(MP_QSTR_get_Sensor6ErrorCode, 6329, 20, "get_Sensor6ErrorCode")
QDEF(MP_QSTR_get_Sensor6NodeType, 916, 19, "get_Sensor6NodeType")
QDEF(MP_QSTR_get_Sensor6NodeTypeMatchError, 61343, 29, "get_Sensor6NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor6SerialInt, 62975, 20, "get_Sensor6SerialInt")
QDEF(MP_QSTR_get_Sensor6SerialMatchError, 18407, 27, "get_Sensor6SerialMatchError")
QDEF(MP_QSTR_get_Sensor6SerialResolveError, 50368, 29, "get_Sensor6SerialResolveError")
QDEF(MP_QSTR_get_Sensor6UnexpectedError, 26353, 26, "get_Sensor6UnexpectedError")
QDEF(MP_QSTR_get_Sensor7AbstractType, 65461, 23, "get_Sensor7AbstractType")
QDEF(MP_QSTR_get_Sensor7AbstractTypeError, 14061, 28, "get_Sensor7AbstractTypeError")
QDEF(MP_QSTR_get_Sensor7AddrAssignError, 54919, 26, "get_Sensor7AddrAssignError")
QDEF(MP_QSTR_get_Sensor7Address, 61275, 18, "get_Sensor7Address")
QDEF(MP_QSTR_get_Sensor7CommsError, 56778, 21, "get_Sensor7CommsError")
QDEF(MP_QSTR_get_Sensor7ErrorCode, 6360, 20, "get_Sensor7ErrorCode")
QDEF(MP_QSTR_get_Sensor7NodeType, 42133, 19, "get_Sensor7NodeType")
QDEF(MP_QSTR_get_Sensor7NodeTypeMatchError, 11742, 29, "get_Sensor7NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor7SerialInt, 62942, 20, "get_Sensor7SerialInt")
QDEF(MP_QSTR_get_Sensor7SerialMatchError, 14438, 27, "get_Sensor7SerialMatchError")
QDEF(MP_QSTR_get_Sensor7SerialResolveError, 28161, 29, "get_Sensor7SerialResolveError")
QDEF(MP_QSTR_get_Sensor7UnexpectedError, 31440, 26, "get_Sensor7UnexpectedError")
QDEF(MP_QSTR_get_Sensor8AbstractType, 23290, 23, "get_Sensor8AbstractType")
QDEF(MP_QSTR_get_Sensor8AbstractTypeError, 17794, 28, "get_Sensor8AbstractTypeError")
QDEF(MP_QSTR_get_Sensor8AddrAssignError, 49128, 26, "get_Sensor8AddrAssignError")
QDEF(MP_QSTR_get_Sensor8Address, 3380, 18, "get_Sensor8Address")
QDEF(MP_QSTR_get_Sensor8CommsError, 62213, 21, "get_Sensor8CommsError")
QDEF(MP_QSTR_get_Sensor8ErrorCode, 55159, 20, "get_Sensor8ErrorCode")
QDEF(MP_QSTR_get_Sensor8NodeType, 9242, 19, "get_Sensor8NodeType")
QDEF(MP_QSTR_get_Sensor8NodeTypeMatchError, 43025, 29, "get_Sensor8NodeTypeMatchError")
QDEF(MP_QSTR_get_Sensor8SerialInt, 1457, 20, "get_Sensor8SerialInt")
QDEF(MP_QSTR_get_Sensor8SerialMatchError, 35049, 27, "get_Sensor8SerialMatchError")
QDEF(MP_QSTR_get_Sensor8SerialResolveError, 13774, 29, "get_Sensor8SerialResolveError")
QDEF(MP_QSTR_get_Sensor8UnexpectedError, 38335, 26, "get_Sensor8UnexpectedError")
QDEF(MP_QSTR_get_SerialInt, 26239, 13, "get_SerialInt")
QDEF(MP_QSTR_get_SerialIntSlot0, 2123, 18, "get_SerialIntSlot0")
QDEF(MP_QSTR_get_SerialIntSlot1, 2122, 18, "get_SerialIntSlot1")
QDEF(MP_QSTR_get_SerialIntSlot2, 2121, 18, "get_SerialIntSlot2")
QDEF(MP_QSTR_get_SerialIntSlot3, 2120, 18, "get_SerialIntSlot3")
QDEF(MP_QSTR_get_SerialMismatchError, 62320, 23, "get_SerialMismatchError")
QDEF(MP_QSTR_get_SetupError, 47635, 14, "get_SetupError")
QDEF(MP_QSTR_get_SharedParamsError, 28417, 21, "get_SharedParamsError")
QDEF(MP_QSTR_get_Size, 14025, 8, "get_Size")
QDEF(MP_QSTR_get_Sram1Current, 28633, 16, "get_Sram1Current")
QDEF(MP_QSTR_get_Sram2Current, 15610, 16, "get_Sram2Current")
QDEF(MP_QSTR_get_State, 6171, 9, "get_State")
QDEF(MP_QSTR_get_Str0AcqSynthFlags, 58397, 21, "get_Str0AcqSynthFlags")
QDEF(MP_QSTR_get_Str0AngVelX, 53542, 15, "get_Str0AngVelX")
QDEF(MP_QSTR_get_Str0AngVelY, 53543, 15, "get_Str0AngVelY")
QDEF(MP_QSTR_get_Str0AngVelZ, 53540, 15, "get_Str0AngVelZ")
QDEF(MP_QSTR_get_Str0BackGroundValues, 13119, 24, "get_Str0BackGroundValues")
QDEF(MP_QSTR_get_Str0BlocksValidity, 2497, 22, "get_Str0BlocksValidity")
QDEF(MP_QSTR_get_Str0CaptureStatus, 9945, 21, "get_Str0CaptureStatus")
QDEF(MP_QSTR_get_Str0CmosChipIdResult, 24397, 24, "get_Str0CmosChipIdResult")
QDEF(MP_QSTR_get_Str0Current, 25536, 15, "get_Str0Current")
QDEF(MP_QSTR_get_Str0CurrentPk, 19963, 17, "get_Str0CurrentPk")
QDEF(MP_QSTR_get_Str0DataValid, 64463, 17, "get_Str0DataValid")
QDEF(MP_QSTR_get_Str0DateMesFil, 46085, 18, "get_Str0DateMesFil")
QDEF(MP_QSTR_get_Str0DetectStatus, 61722, 20, "get_Str0DetectStatus")
QDEF(MP_QSTR_get_Str0DetectorPcbTemp, 30830, 23, "get_Str0DetectorPcbTemp")
QDEF(MP_QSTR_get_Str0DeviceNumber, 26546, 20, "get_Str0DeviceNumber")
QDEF(MP_QSTR_get_Str0DynamicMode, 20191, 19, "get_Str0DynamicMode")
QDEF(MP_QSTR_get_Str0EdacErrorCount, 9905, 22, "get_Str0EdacErrorCount")
QDEF(MP_QSTR_get_Str0EdacSwitch, 10296, 18, "get_Str0EdacSwitch")
QDEF(MP_QSTR_get_Str0ErrorCode, 57628, 17, "get_Str0ErrorCode")
QDEF(MP_QSTR_get_Str0ErrorInfo, 7327, 17, "get_Str0ErrorInfo")
QDEF(MP_QSTR_get_Str0ExtImageState, 53200, 21, "get_Str0ExtImageState")
QDEF(MP_QSTR_get_Str0FourStarCaptureThreshold, 49568, 32, "get_Str0FourStarCaptureThreshold")
QDEF(MP_QSTR_get_Str0Fpga1Current, 14817, 20, "get_Str0Fpga1Current")
QDEF(MP_QSTR_get_Str0Fpga1Voltage, 13066, 20, "get_Str0Fpga1Voltage")
QDEF(MP_QSTR_get_Str0Fpga2Current, 898, 20, "get_Str0Fpga2Current")
QDEF(MP_QSTR_get_Str0Fpga2Voltage, 42345, 20, "get_Str0Fpga2Voltage")
QDEF(MP_QSTR_get_Str0FpgaMRamResult, 30659, 22, "get_Str0FpgaMRamResult")
QDEF(MP_QSTR_get_Str0FrameCnt, 21261, 16, "get_Str0FrameCnt")
QDEF(MP_QSTR_get_Str0IDSATM, 25999, 14, "get_Str0IDSATM")
QDEF(MP_QSTR_get_Str0IQFilXRs, 64971, 16, "get_Str0IQFilXRs")
QDEF(MP_QSTR_get_Str0IQFilYRs, 4618, 16, "get_Str0IQFilYRs")
QDEF(MP_QSTR_get_Str0IQFilZRs, 1609, 16, "get_Str0IQFilZRs")
QDEF(MP_QSTR_get_Str0IdentStatus, 31407, 19, "get_Str0IdentStatus")
QDEF(MP_QSTR_get_Str0IdentifiedStars, 25051, 23, "get_Str0IdentifiedStars")
QDEF(MP_QSTR_get_Str0Idle, 52493, 12, "get_Str0Idle")
QDEF(MP_QSTR_get_Str0ImageExposure, 34973, 21, "get_Str0ImageExposure")
QDEF(MP_QSTR_get_Str0ImageFrameNumber, 20080, 24, "get_Str0ImageFrameNumber")
QDEF(MP_QSTR_get_Str0ImageThreshold, 11609, 22, "get_Str0ImageThreshold")
QDEF(MP_QSTR_get_Str0ImagingGain, 8010, 19, "get_Str0ImagingGain")
QDEF(MP_QSTR_get_Str0InternalProcessCode, 872, 27, "get_Str0InternalProcessCode")
QDEF(MP_QSTR_get_Str0IsValid, 34725, 15, "get_Str0IsValid")
QDEF(MP_QSTR_get_Str0LastErrorId, 54678, 19, "get_Str0LastErrorId")
QDEF(MP_QSTR_get_Str0LastErrorParam, 38068, 22, "get_Str0LastErrorParam")
QDEF(MP_QSTR_get_Str0LastTCSeqNum, 21733, 20, "get_Str0LastTCSeqNum")
QDEF(MP_QSTR_get_Str0McuCurrent, 36539, 18, "get_Str0McuCurrent")
QDEF(MP_QSTR_get_Str0McuTemp, 38366, 15, "get_Str0McuTemp")
QDEF(MP_QSTR_get_Str0McuVoltage, 15568, 18, "get_Str0McuVoltage")
QDEF(MP_QSTR_get_Str0MeasBodyVec0X, 35387, 21, "get_Str0MeasBodyVec0X")
QDEF(MP_QSTR_get_Str0MeasBodyVec0Y, 35386, 21, "get_Str0MeasBodyVec0Y")
QDEF(MP_QSTR_get_Str0MeasBodyVec0Z, 35385, 21, "get_Str0MeasBodyVec0Z")
QDEF(MP_QSTR_get_Str0MeasBodyVec1X, 35354, 21, "get_Str0MeasBodyVec1X")
QDEF(MP_QSTR_get_Str0MeasBodyVec1Y, 35355, 21, "get_Str0MeasBodyVec1Y")
QDEF(MP_QSTR_get_Str0MeasBodyVec1Z, 35352, 21, "get_Str0MeasBodyVec1Z")
QDEF(MP_QSTR_get_Str0MeasBodyVec2X, 35449, 21, "get_Str0MeasBodyVec2X")
QDEF(MP_QSTR_get_Str0MeasBodyVec2Y, 35448, 21, "get_Str0MeasBodyVec2Y")
QDEF(MP_QSTR_get_Str0MeasBodyVec2Z, 35451, 21, "get_Str0MeasBodyVec2Z")
QDEF(MP_QSTR_get_Str0MeasQ0, 46898, 14, "get_Str0MeasQ0")
QDEF(MP_QSTR_get_Str0MeasQ1, 46899, 14, "get_Str0MeasQ1")
QDEF(MP_QSTR_get_Str0MeasQ2, 46896, 14, "get_Str0MeasQ2")
QDEF(MP_QSTR_get_Str0MeasQ3, 46897, 14, "get_Str0MeasQ3")
QDEF(MP_QSTR_get_Str0MeasVec0X, 523, 17, "get_Str0MeasVec0X")
QDEF(MP_QSTR_get_Str0MeasVec0Y, 522, 17, "get_Str0MeasVec0Y")
QDEF(MP_QSTR_get_Str0MeasVec0Z, 521, 17, "get_Str0MeasVec0Z")
QDEF(MP_QSTR_get_Str0MeasVec1X, 618, 17, "get_Str0MeasVec1X")
QDEF(MP_QSTR_get_Str0MeasVec1Y, 619, 17, "get_Str0MeasVec1Y")
QDEF(MP_QSTR_get_Str0MeasVec1Z, 616, 17, "get_Str0MeasVec1Z")
QDEF(MP_QSTR_get_Str0MeasVec2X, 585, 17, "get_Str0MeasVec2X")
QDEF(MP_QSTR_get_Str0MeasVec2Y, 584, 17, "get_Str0MeasVec2Y")
QDEF(MP_QSTR_get_Str0MeasVec2Z, 587, 17, "get_Str0MeasVec2Z")
QDEF(MP_QSTR_get_Str0MinNavigationStars, 2254, 26, "get_Str0MinNavigationStars")
QDEF(MP_QSTR_get_Str0ModelOrbitVec0X, 45916, 23, "get_Str0ModelOrbitVec0X")
QDEF(MP_QSTR_get_Str0ModelOrbitVec0Y, 45917, 23, "get_Str0ModelOrbitVec0Y")
QDEF(MP_QSTR_get_Str0ModelOrbitVec0Z, 45918, 23, "get_Str0ModelOrbitVec0Z")
QDEF(MP_QSTR_get_Str0ModelOrbitVec1X, 45949, 23, "get_Str0ModelOrbitVec1X")
QDEF(MP_QSTR_get_Str0ModelOrbitVec1Y, 45948, 23, "get_Str0ModelOrbitVec1Y")
QDEF(MP_QSTR_get_Str0ModelOrbitVec1Z, 45951, 23, "get_Str0ModelOrbitVec1Z")
QDEF(MP_QSTR_get_Str0ModelOrbitVec2X, 45854, 23, "get_Str0ModelOrbitVec2X")
QDEF(MP_QSTR_get_Str0ModelOrbitVec2Y, 45855, 23, "get_Str0ModelOrbitVec2Y")
QDEF(MP_QSTR_get_Str0ModelOrbitVec2Z, 45852, 23, "get_Str0ModelOrbitVec2Z")
QDEF(MP_QSTR_get_Str0ModelVec0X, 2174, 18, "get_Str0ModelVec0X")
QDEF(MP_QSTR_get_Str0ModelVec0Y, 2175, 18, "get_Str0ModelVec0Y")
QDEF(MP_QSTR_get_Str0ModelVec0Z, 2172, 18, "get_Str0ModelVec0Z")
QDEF(MP_QSTR_get_Str0ModelVec1X, 2079, 18, "get_Str0ModelVec1X")
QDEF(MP_QSTR_get_Str0ModelVec1Y, 2078, 18, "get_Str0ModelVec1Y")
QDEF(MP_QSTR_get_Str0ModelVec1Z, 2077, 18, "get_Str0ModelVec1Z")
QDEF(MP_QSTR_get_Str0ModelVec2X, 1980, 18, "get_Str0ModelVec2X")
QDEF(MP_QSTR_get_Str0ModelVec2Y, 1981, 18, "get_Str0ModelVec2Y")
QDEF(MP_QSTR_get_Str0ModelVec2Z, 1982, 18, "get_Str0ModelVec2Z")
QDEF(MP_QSTR_get_Str0NLPMoyOH1, 65174, 17, "get_Str0NLPMoyOH1")
QDEF(MP_QSTR_get_Str0NLPMoyOH2, 65173, 17, "get_Str0NLPMoyOH2")
QDEF(MP_QSTR_get_Str0NbEtoAtt, 12090, 16, "get_Str0NbEtoAtt")
QDEF(MP_QSTR_get_Str0NbEtoAttOH, 56477, 18, "get_Str0NbEtoAttOH")
QDEF(MP_QSTR_get_Str0NbEtoCoh, 14559, 16, "get_Str0NbEtoCoh")
QDEF(MP_QSTR_get_Str0NbEtoCohOH, 62136, 18, "get_Str0NbEtoCohOH")
QDEF(MP_QSTR_get_Str0NumDetected, 8505, 19, "get_Str0NumDetected")
QDEF(MP_QSTR_get_Str0NumIdentified, 55114, 21, "get_Str0NumIdentified")
QDEF(MP_QSTR_get_Str0NumberOfExtractedStars, 26024, 30, "get_Str0NumberOfExtractedStars")
QDEF(MP_QSTR_get_Str0OH1State, 36648, 16, "get_Str0OH1State")
QDEF(MP_QSTR_get_Str0OH1Temp, 48723, 15, "get_Str0OH1Temp")
QDEF(MP_QSTR_get_Str0OH2State, 331, 16, "get_Str0OH2State")
QDEF(MP_QSTR_get_Str0OH2Temp, 34000, 15, "get_Str0OH2Temp")
QDEF(MP_QSTR_get_Str0Oh1Current, 58806, 18, "get_Str0Oh1Current")
QDEF(MP_QSTR_get_Str0Oh2Current, 14741, 18, "get_Str0Oh2Current")
QDEF(MP_QSTR_get_Str0OperatingMode, 14519, 21, "get_Str0OperatingMode")
QDEF(MP_QSTR_get_Str0Power, 51958, 13, "get_Str0Power")
QDEF(MP_QSTR_get_Str0ProcessIdleTiming, 63606, 25, "get_Str0ProcessIdleTiming")
QDEF(MP_QSTR_get_Str0Pst3sCurrent, 30935, 20, "get_Str0Pst3sCurrent")
QDEF(MP_QSTR_get_Str0Pst3sOvercurrent, 12121, 24, "get_Str0Pst3sOvercurrent")
QDEF(MP_QSTR_get_Str0Pst3sVersion, 47044, 20, "get_Str0Pst3sVersion")
QDEF(MP_QSTR_get_Str0QRsFil1, 62571, 15, "get_Str0QRsFil1")
QDEF(MP_QSTR_get_Str0QRsFil2, 62568, 15, "get_Str0QRsFil2")
QDEF(MP_QSTR_get_Str0QRsFil3, 62569, 15, "get_Str0QRsFil3")
QDEF(MP_QSTR_get_Str0QRsFil4, 62574, 15, "get_Str0QRsFil4")
QDEF(MP_QSTR_get_Str0Quat1, 25737, 13, "get_Str0Quat1")
QDEF(MP_QSTR_get_Str0Quat2, 25738, 13, "get_Str0Quat2")
QDEF(MP_QSTR_get_Str0Quat3, 25739, 13, "get_Str0Quat3")
QDEF(MP_QSTR_get_Str0Quat4, 25740, 13, "get_Str0Quat4")
QDEF(MP_QSTR_get_Str0QuaternionFilteringState, 6366, 32, "get_Str0QuaternionFilteringState")
QDEF(MP_QSTR_get_Str0RateQuality, 54694, 19, "get_Str0RateQuality")
QDEF(MP_QSTR_get_Str0RateX, 61779, 13, "get_Str0RateX")
QDEF(MP_QSTR_get_Str0RateY, 61778, 13, "get_Str0RateY")
QDEF(MP_QSTR_get_Str0RateZ, 61777, 13, "get_Str0RateZ")
QDEF(MP_QSTR_get_Str0ResetCnt, 62117, 16, "get_Str0ResetCnt")
QDEF(MP_QSTR_get_Str0STRMode, 8511, 15, "get_Str0STRMode")
QDEF(MP_QSTR_get_Str0SaaMode, 6105, 15, "get_Str0SaaMode")
QDEF(MP_QSTR_get_Str0SaaThreshold, 45101, 20, "get_Str0SaaThreshold")
QDEF(MP_QSTR_get_Str0SensorConfigOk, 36945, 22, "get_Str0SensorConfigOk")
QDEF(MP_QSTR_get_Str0SensorInitOk, 12289, 20, "get_Str0SensorInitOk")
QDEF(MP_QSTR_get_Str0SoftwareVersion, 5084, 23, "get_Str0SoftwareVersion")
QDEF(MP_QSTR_get_Str0SpecTC, 16187, 14, "get_Str0SpecTC")
QDEF(MP_QSTR_get_Str0SramCurrent, 23821, 19, "get_Str0SramCurrent")
QDEF(MP_QSTR_get_Str0StarIdCount, 25427, 19, "get_Str0StarIdCount")
QDEF(MP_QSTR_get_Str0State, 21246, 13, "get_Str0State")
QDEF(MP_QSTR_get_Str0SyntDefATM, 29638, 18, "get_Str0SyntDefATM")
QDEF(MP_QSTR_get_Str0SyntDesOH1, 64093, 18, "get_Str0SyntDesOH1")
QDEF(MP_QSTR_get_Str0SyntDesOH2, 64094, 18, "get_Str0SyntDesOH2")
QDEF(MP_QSTR_get_Str0SyntFDIROH1, 982, 19, "get_Str0SyntFDIROH1")
QDEF(MP_QSTR_get_Str0SyntFDIROH2, 981, 19, "get_Str0SyntFDIROH2")
QDEF(MP_QSTR_get_Str0SyntFil, 28314, 15, "get_Str0SyntFil")
QDEF(MP_QSTR_get_Str0SyntFilOH1, 1068, 18, "get_Str0SyntFilOH1")
QDEF(MP_QSTR_get_Str0SyntFilOH2, 1071, 18, "get_Str0SyntFilOH2")
QDEF(MP_QSTR_get_Str0SyntFusion, 25201, 18, "get_Str0SyntFusion")
QDEF(MP_QSTR_get_Str0TCCnt, 44295, 13, "get_Str0TCCnt")
QDEF(MP_QSTR_get_Str0TRKLossCnt, 38174, 18, "get_Str0TRKLossCnt")
QDEF(MP_QSTR_get_Str0Temperature, 26117, 19, "get_Str0Temperature")
QDEF(MP_QSTR_get_Str0Tracking, 45990, 16, "get_Str0Tracking")
QDEF(MP_QSTR_get_Str0TrackingThreshold, 1809, 25, "get_Str0TrackingThreshold")
QDEF(MP_QSTR_get_Str0UnixSeconds, 55424, 19, "get_Str0UnixSeconds")
QDEF(MP_QSTR_get_Str0UnixSecondsDecimal, 32747, 26, "get_Str0UnixSecondsDecimal")
QDEF(MP_QSTR_get_Str0WRsFil1, 48493, 15, "get_Str0WRsFil1")
QDEF(MP_QSTR_get_Str0WRsFil2, 48494, 15, "get_Str0WRsFil2")
QDEF(MP_QSTR_get_Str0WRsFil3, 48495, 15, "get_Str0WRsFil3")
QDEF(MP_QSTR_get_Str1AcqSynthFlags, 30460, 21, "get_Str1AcqSynthFlags")
QDEF(MP_QSTR_get_Str1AngVelX, 36551, 15, "get_Str1AngVelX")
QDEF(MP_QSTR_get_Str1AngVelY, 36550, 15, "get_Str1AngVelY")
QDEF(MP_QSTR_get_Str1AngVelZ, 36549, 15, "get_Str1AngVelZ")
QDEF(MP_QSTR_get_Str1BackGroundValues, 41982, 24, "get_Str1BackGroundValues")
QDEF(MP_QSTR_get_Str1BlocksValidity, 38208, 22, "get_Str1BlocksValidity")
QDEF(MP_QSTR_get_Str1CaptureStatus, 9912, 21, "get_Str1CaptureStatus")
QDEF(MP_QSTR_get_Str1CmosChipIdResult, 12364, 24, "get_Str1CmosChipIdResult")
QDEF(MP_QSTR_get_Str1Current, 225, 15, "get_Str1Current")
QDEF(MP_QSTR_get_Str1CurrentPk, 50970, 17, "get_Str1CurrentPk")
QDEF(MP_QSTR_get_Str1DataValid, 15086, 17, "get_Str1DataValid")
QDEF(MP_QSTR_get_Str1DateMesFil, 6084, 18, "get_Str1DateMesFil")
QDEF(MP_QSTR_get_Str1DetectStatus, 4379, 20, "get_Str1DetectStatus")
QDEF(MP_QSTR_get_Str1DetectorPcbTemp, 30991, 23, "get_Str1DetectorPcbTemp")
QDEF(MP_QSTR_get_Str1DeviceNumber, 33011, 20, "get_Str1DeviceNumber")
QDEF(MP_QSTR_get_Str1DynamicMode, 58174, 19, "get_Str1DynamicMode")
QDEF(MP_QSTR_get_Str1EdacErrorCount, 23088, 22, "get_Str1EdacErrorCount")
QDEF(MP_QSTR_get_Str1EdacSwitch, 29689, 18, "get_Str1EdacSwitch")
QDEF(MP_QSTR_get_Str1ErrorCode, 509, 17, "get_Str1ErrorCode")
QDEF(MP_QSTR_get_Str1ErrorInfo, 5502, 17, "get_Str1ErrorInfo")
QDEF(MP_QSTR_get_Str1ExtImageState, 57265, 21, "get_Str1ExtImageState")
QDEF(MP_QSTR_get_Str1FourStarCaptureThreshold, 35489, 32, "get_Str1FourStarCaptureThreshold")
QDEF(MP_QSTR_get_Str1Fpga1Current, 8544, 20, "get_Str1Fpga1Current")
QDEF(MP_QSTR_get_Str1Fpga1Voltage, 21067, 20, "get_Str1Fpga1Voltage")
QDEF(MP_QSTR_get_Str1Fpga2Current, 17603, 20, "get_Str1Fpga2Current")
QDEF(MP_QSTR_get_Str1Fpga2Voltage, 28648, 20, "get_Str1Fpga2Voltage")
QDEF(MP_QSTR_get_Str1FpgaMRamResult, 31618, 22, "get_Str1FpgaMRamResult")
QDEF(MP_QSTR_get_Str1FrameCnt, 15052, 16, "get_Str1FrameCnt")
QDEF(MP_QSTR_get_Str1IDSATM, 14798, 14, "get_Str1IDSATM")
QDEF(MP_QSTR_get_Str1IQFilXRs, 47050, 16, "get_Str1IQFilXRs")
QDEF(MP_QSTR_get_Str1IQFilYRs, 50059, 16, "get_Str1IQFilYRs")
QDEF(MP_QSTR_get_Str1IQFilZRs, 49224, 16, "get_Str1IQFilZRs")
QDEF(MP_QSTR_get_Str1IdentStatus, 48462, 19, "get_Str1IdentStatus")
QDEF(MP_QSTR_get_Str1IdentifiedStars, 32250, 23, "get_Str1IdentifiedStars")
QDEF(MP_QSTR_get_Str1Idle, 50444, 12, "get_Str1Idle")
QDEF(MP_QSTR_get_Str1ImageExposure, 63868, 21, "get_Str1ImageExposure")
QDEF(MP_QSTR_get_Str1ImageFrameNumber, 52721, 24, "get_Str1ImageFrameNumber")
QDEF(MP_QSTR_get_Str1ImageThreshold, 51480, 22, "get_Str1ImageThreshold")
QDEF(MP_QSTR_get_Str1ImagingGain, 56107, 19, "get_Str1ImagingGain")
QDEF(MP_QSTR_get_Str1InternalProcessCode, 33929, 27, "get_Str1InternalProcessCode")
QDEF(MP_QSTR_get_Str1IsValid, 17540, 15, "get_Str1IsValid")
QDEF(MP_QSTR_get_Str1LastErrorId, 47607, 19, "get_Str1LastErrorId")
QDEF(MP_QSTR_get_Str1LastErrorParam, 26421, 22, "get_Str1LastErrorParam")
QDEF(MP_QSTR_get_Str1LastTCSeqNum, 52388, 20, "get_Str1LastTCSeqNum")
QDEF(MP_QSTR_get_Str1McuCurrent, 13114, 18, "get_Str1McuCurrent")
QDEF(MP_QSTR_get_Str1McuTemp, 29375, 15, "get_Str1McuTemp")
QDEF(MP_QSTR_get_Str1McuVoltage, 6161, 18, "get_Str1McuVoltage")
QDEF(MP_QSTR_get_Str1MeasBodyVec0X, 19226, 21, "get_Str1MeasBodyVec0X")
QDEF(MP_QSTR_get_Str1MeasBodyVec0Y, 19227, 21, "get_Str1MeasBodyVec0Y")
QDEF(MP_QSTR_get_Str1MeasBodyVec0Z, 19224, 21, "get_Str1MeasBodyVec0Z")
QDEF(MP_QSTR_get_Str1MeasBodyVec1X, 19259, 21, "get_Str1MeasBodyVec1X")
QDEF(MP_QSTR_get_Str1MeasBodyVec1Y, 19258, 21, "get_Str1MeasBodyVec1Y")
QDEF(MP_QSTR_get_Str1MeasBodyVec1Z, 19257, 21, "get_Str1MeasBodyVec1Z")
QDEF(MP_QSTR_get_Str1MeasBodyVec2X, 19288, 21, "get_Str1MeasBodyVec2X")
QDEF(MP_QSTR_get_Str1MeasBodyVec2Y, 19289, 21, "get_Str1MeasBodyVec2Y")
QDEF(MP_QSTR_get_Str1MeasBodyVec2Z, 19290, 21, "get_Str1MeasBodyVec2Z")
QDEF(MP_QSTR_get_Str1MeasQ0, 58355, 14, "get_Str1MeasQ0")
QDEF(MP_QSTR_get_Str1MeasQ1, 58354, 14, "get_Str1MeasQ1")
QDEF(MP_QSTR_get_Str1MeasQ2, 58353, 14, "get_Str1MeasQ2")
QDEF(MP_QSTR_get_Str1MeasQ3, 58352, 14, "get_Str1MeasQ3")
QDEF(MP_QSTR_get_Str1MeasVec0X, 21034, 17, "get_Str1MeasVec0X")
QDEF(MP_QSTR_get_Str1MeasVec0Y, 21035, 17, "get_Str1MeasVec0Y")
QDEF(MP_QSTR_get_Str1MeasVec0Z, 21032, 17, "get_Str1MeasVec0Z")
QDEF(MP_QSTR_get_Str1MeasVec1X, 21195, 17, "get_Str1MeasVec1X")
QDEF(MP_QSTR_get_Str1MeasVec1Y, 21194, 17, "get_Str1MeasVec1Y")
QDEF(MP_QSTR_get_Str1MeasVec1Z, 21193, 17, "get_Str1MeasVec1Z")
QDEF(MP_QSTR_get_Str1MeasVec2X, 21096, 17, "get_Str1MeasVec2X")
QDEF(MP_QSTR_get_Str1MeasVec2Y, 21097, 17, "get_Str1MeasVec2Y")
QDEF(MP_QSTR_get_Str1MeasVec2Z, 21098, 17, "get_Str1MeasVec2Z")
QDEF(MP_QSTR_get_Str1MinNavigationStars, 60879, 26, "get_Str1MinNavigationStars")
QDEF(MP_QSTR_get_Str1ModelOrbitVec0X, 54973, 23, "get_Str1ModelOrbitVec0X")
QDEF(MP_QSTR_get_Str1ModelOrbitVec0Y, 54972, 23, "get_Str1ModelOrbitVec0Y")
QDEF(MP_QSTR_get_Str1ModelOrbitVec0Z, 54975, 23, "get_Str1ModelOrbitVec0Z")
QDEF(MP_QSTR_get_Str1ModelOrbitVec1X, 54940, 23, "get_Str1ModelOrbitVec1X")
QDEF(MP_QSTR_get_Str1ModelOrbitVec1Y, 54941, 23, "get_Str1ModelOrbitVec1Y")
QDEF(MP_QSTR_get_Str1ModelOrbitVec1Z, 54942, 23, "get_Str1ModelOrbitVec1Z")
QDEF(MP_QSTR_get_Str1ModelOrbitVec2X, 55167, 23, "get_Str1ModelOrbitVec2X")
QDEF(MP_QSTR_get_Str1ModelOrbitVec2Y, 55166, 23, "get_Str1ModelOrbitVec2Y")
QDEF(MP_QSTR_get_Str1ModelOrbitVec2Z, 55165, 23, "get_Str1ModelOrbitVec2Z")
QDEF(MP_QSTR_get_Str1ModelVec0X, 3135, 18, "get_Str1ModelVec0X")
QDEF(MP_QSTR_get_Str1ModelVec0Y, 3134, 18, "get_Str1ModelVec0Y")
QDEF(MP_QSTR_get_Str1ModelVec0Z, 3133, 18, "get_Str1ModelVec0Z")
QDEF(MP_QSTR_get_Str1ModelVec1X, 3102, 18, "get_Str1ModelVec1X")
QDEF(MP_QSTR_get_Str1ModelVec1Y, 3103, 18, "get_Str1ModelVec1Y")
QDEF(MP_QSTR_get_Str1ModelVec1Z, 3100, 18, "get_Str1ModelVec1Z")
QDEF(MP_QSTR_get_Str1ModelVec2X, 3197, 18, "get_Str1ModelVec2X")
QDEF(MP_QSTR_get_Str1ModelVec2Y, 3196, 18, "get_Str1ModelVec2Y")
QDEF(MP_QSTR_get_Str1ModelVec2Z, 3199, 18, "get_Str1ModelVec2Z")
QDEF(MP_QSTR_get_Str1NLPMoyOH1, 3575, 17, "get_Str1NLPMoyOH1")
QDEF(MP_QSTR_get_Str1NLPMoyOH2, 3572, 17, "get_Str1NLPMoyOH2")
QDEF(MP_QSTR_get_Str1NbEtoAtt, 20539, 16, "get_Str1NbEtoAtt")
QDEF(MP_QSTR_get_Str1NbEtoAttOH, 21020, 18, "get_Str1NbEtoAttOH")
QDEF(MP_QSTR_get_Str1NbEtoCoh, 14366, 16, "get_Str1NbEtoCoh")
QDEF(MP_QSTR_get_Str1NbEtoCohOH, 44537, 18, "get_Str1NbEtoCohOH")
QDEF(MP_QSTR_get_Str1NumDetected, 58328, 19, "get_Str1NumDetected")
QDEF(MP_QSTR_get_Str1NumIdentified, 40875, 21, "get_Str1NumIdentified")
QDEF(MP_QSTR_get_Str1NumberOfExtractedStars, 56105, 30, "get_Str1NumberOfExtractedStars")
QDEF(MP_QSTR_get_Str1OH1State, 14569, 16, "get_Str1OH1State")
QDEF(MP_QSTR_get_Str1OH1Temp, 31474, 15, "get_Str1OH1Temp")
QDEF(MP_QSTR_get_Str1OH2State, 18890, 16, "get_Str1OH2State")
QDEF(MP_QSTR_get_Str1OH2Temp, 16881, 15, "get_Str1OH2Temp")
QDEF(MP_QSTR_get_Str1Oh1Current, 14647, 18, "get_Str1Oh1Current")
QDEF(MP_QSTR_get_Str1Oh2Current, 13652, 18, "get_Str1Oh2Current")
QDEF(MP_QSTR_get_Str1OperatingMode, 20950, 21, "get_Str1OperatingMode")
QDEF(MP_QSTR_get_Str1Power, 37463, 13, "get_Str1Power")
QDEF(MP_QSTR_get_Str1ProcessIdleTiming, 63191, 25, "get_Str1ProcessIdleTiming")
QDEF(MP_QSTR_get_Str1Pst3sCurrent, 38678, 20, "get_Str1Pst3sCurrent")
QDEF(MP_QSTR_get_Str1Pst3sOvercurrent, 61080, 24, "get_Str1Pst3sOvercurrent")
QDEF(MP_QSTR_get_Str1Pst3sVersion, 22277, 20, "get_Str1Pst3sVersion")
QDEF(MP_QSTR_get_Str1QRsFil1, 36938, 15, "get_Str1QRsFil1")
QDEF(MP_QSTR_get_Str1QRsFil2, 36937, 15, "get_Str1QRsFil2")
QDEF(MP_QSTR_get_Str1QRsFil3, 36936, 15, "get_Str1QRsFil3")
QDEF(MP_QSTR_get_Str1QRsFil4, 36943, 15, "get_Str1QRsFil4")
QDEF(MP_QSTR_get_Str1Quat1, 32168, 13, "get_Str1Quat1")
QDEF(MP_QSTR_get_Str1Quat2, 32171, 13, "get_Str1Quat2")
QDEF(MP_QSTR_get_Str1Quat3, 32170, 13, "get_Str1Quat3")
QDEF(MP_QSTR_get_Str1Quat4, 32173, 13, "get_Str1Quat4")
QDEF(MP_QSTR_get_Str1QuaternionFilteringState, 5663, 32, "get_Str1QuaternionFilteringState")
QDEF(MP_QSTR_get_Str1RateQuality, 61703, 19, "get_Str1RateQuality")
QDEF(MP_QSTR_get_Str1RateX, 12914, 13, "get_Str1RateX")
QDEF(MP_QSTR_get_Str1RateY, 12915, 13, "get_Str1RateY")
QDEF(MP_QSTR_get_Str1RateZ, 12912, 13, "get_Str1RateZ")
QDEF(MP_QSTR_get_Str1ResetCnt, 19236, 16, "get_Str1ResetCnt")
QDEF(MP_QSTR_get_Str1STRMode, 38174, 15, "get_Str1STRMode")
QDEF(MP_QSTR_get_Str1SaaMode, 27448, 15, "get_Str1SaaMode")
QDEF(MP_QSTR_get_Str1SaaThreshold, 10284, 20, "get_Str1SaaThreshold")
QDEF(MP_QSTR_get_Str1SensorConfigOk, 31696, 22, "get_Str1SensorConfigOk")
QDEF(MP_QSTR_get_Str1SensorInitOk, 12288, 20, "get_Str1SensorInitOk")
QDEF(MP_QSTR_get_Str1SoftwareVersion, 22397, 23, "get_Str1SoftwareVersion")
QDEF(MP_QSTR_get_Str1SpecTC, 19386, 14, "get_Str1SpecTC")
QDEF(MP_QSTR_get_Str1SramCurrent, 33324, 19, "get_Str1SramCurrent")
QDEF(MP_QSTR_get_Str1StarIdCount, 42738, 19, "get_Str1StarIdCount")
QDEF(MP_QSTR_get_Str1State, 21215, 13, "get_Str1State")
QDEF(MP_QSTR_get_Str1SyntDefATM, 26695, 18, "get_Str1SyntDefATM")
QDEF(MP_QSTR_get_Str1SyntDesOH1, 42396, 18, "get_Str1SyntDesOH1")
QDEF(MP_QSTR_get_Str1SyntDesOH2, 42399, 18, "get_Str1SyntDesOH2")
QDEF(MP_QSTR_get_Str1SyntFDIROH1, 10679, 19, "get_Str1SyntFDIROH1")
QDEF(MP_QSTR_get_Str1SyntFDIROH2, 10676, 19, "get_Str1SyntFDIROH2")
QDEF(MP_QSTR_get_Str1SyntFil, 62267, 15, "get_Str1SyntFil")
QDEF(MP_QSTR_get_Str1SyntFilOH1, 22701, 18, "get_Str1SyntFilOH1")
QDEF(MP_QSTR_get_Str1SyntFilOH2, 22702, 18, "get_Str1SyntFilOH2")
QDEF(MP_QSTR_get_Str1SyntFusion, 38448, 18, "get_Str1SyntFusion")
QDEF(MP_QSTR_get_Str1TCCnt, 21734, 13, "get_Str1TCCnt")
QDEF(MP_QSTR_get_Str1TRKLossCnt, 49375, 18, "get_Str1TRKLossCnt")
QDEF(MP_QSTR_get_Str1Temperature, 18852, 19, "get_Str1Temperature")
QDEF(MP_QSTR_get_Str1Tracking, 55911, 16, "get_Str1Tracking")
QDEF(MP_QSTR_get_Str1TrackingThreshold, 24368, 25, "get_Str1TrackingThreshold")
QDEF(MP_QSTR_get_Str1UnixSeconds, 13089, 19, "get_Str1UnixSeconds")
QDEF(MP_QSTR_get_Str1UnixSecondsDecimal, 33770, 26, "get_Str1UnixSecondsDecimal")
QDEF(MP_QSTR_get_Str1WRsFil1, 47692, 15, "get_Str1WRsFil1")
QDEF(MP_QSTR_get_Str1WRsFil2, 47695, 15, "get_Str1WRsFil2")
QDEF(MP_QSTR_get_Str1WRsFil3, 47694, 15, "get_Str1WRsFil3")
QDEF(MP_QSTR_get_StrR, 747, 8, "get_StrR")
QDEF(MP_QSTR_get_SunAvoidEn, 21018, 14, "get_SunAvoidEn")
QDEF(MP_QSTR_get_SunKeepoutAng, 15129, 17, "get_SunKeepoutAng")
QDEF(MP_QSTR_get_SunPointBodyVecX, 35088, 20, "get_SunPointBodyVecX")
QDEF(MP_QSTR_get_SunPointBodyVecY, 35089, 20, "get_SunPointBodyVecY")
QDEF(MP_QSTR_get_SunPointBodyVecZ, 35090, 20, "get_SunPointBodyVecZ")
QDEF(MP_QSTR_get_SunTrackEclEn, 34634, 17, "get_SunTrackEclEn")
QDEF(MP_QSTR_get_SupplyVoltage, 6269, 17, "get_SupplyVoltage")
QDEF(MP_QSTR_get_SyncTime, 30494, 12, "get_SyncTime")
QDEF(MP_QSTR_get_SystemMajorVersion, 31880, 22, "get_SystemMajorVersion")
QDEF(MP_QSTR_get_SystemMinorVersion, 33796, 22, "get_SystemMinorVersion")
QDEF(MP_QSTR_get_SystemPatchVersion, 63357, 22, "get_SystemPatchVersion")
QDEF(MP_QSTR_get_TVec1, 51865, 9, "get_TVec1")
QDEF(MP_QSTR_get_TVec2, 51866, 9, "get_TVec2")
QDEF(MP_QSTR_get_TargetNode, 3645, 14, "get_TargetNode")
QDEF(MP_QSTR_get_Telemetry_preset_cfg, 47556, 24, "get_Telemetry_preset_cfg")
QDEF(MP_QSTR_get_TgtPosEciX, 45232, 14, "get_TgtPosEciX")
QDEF(MP_QSTR_get_TgtPosEciY, 45233, 14, "get_TgtPosEciY")
QDEF(MP_QSTR_get_TgtPosEciZ, 45234, 14, "get_TgtPosEciZ")
QDEF(MP_QSTR_get_TgtRefAlt, 55395, 13, "get_TgtRefAlt")
QDEF(MP_QSTR_get_TgtRefLat, 52163, 13, "get_TgtRefLat")
QDEF(MP_QSTR_get_TgtRefLon, 52119, 13, "get_TgtRefLon")
QDEF(MP_QSTR_get_TgtTrackBodyVecX, 8380, 20, "get_TgtTrackBodyVecX")
QDEF(MP_QSTR_get_TgtTrackBodyVecY, 8381, 20, "get_TgtTrackBodyVecY")
QDEF(MP_QSTR_get_TgtTrackBodyVecZ, 8382, 20, "get_TgtTrackBodyVecZ")
QDEF(MP_QSTR_get_TimeGain, 30328, 12, "get_TimeGain")
QDEF(MP_QSTR_get_TimeNs, 7716, 10, "get_TimeNs")
QDEF(MP_QSTR_get_TimeSeconds, 36986, 15, "get_TimeSeconds")
QDEF(MP_QSTR_get_TimeSinceLoopStart, 9431, 22, "get_TimeSinceLoopStart")
QDEF(MP_QSTR_get_TimeoutError, 19887, 16, "get_TimeoutError")
QDEF(MP_QSTR_get_Timestamp, 61282, 13, "get_Timestamp")
QDEF(MP_QSTR_get_TlmLogSvc, 25211, 13, "get_TlmLogSvc")
QDEF(MP_QSTR_get_Tow, 3360, 7, "get_Tow")
QDEF(MP_QSTR_get_TransferSize, 17282, 16, "get_TransferSize")
QDEF(MP_QSTR_get_Type, 26996, 8, "get_Type")
QDEF(MP_QSTR_get_UnixTimeNanoSeconds, 8062, 23, "get_UnixTimeNanoSeconds")
QDEF(MP_QSTR_get_UnixTimeSeconds, 47376, 19, "get_UnixTimeSeconds")
QDEF(MP_QSTR_get_UpdateApMa, 17856, 14, "get_UpdateApMa")
QDEF(MP_QSTR_get_UpdateEccen, 47539, 15, "get_UpdateEccen")
QDEF(MP_QSTR_get_UpdateRaanIncl, 17897, 18, "get_UpdateRaanIncl")
QDEF(MP_QSTR_get_UpdateTime, 63240, 14, "get_UpdateTime")
QDEF(MP_QSTR_get_UpgradeState, 5899, 16, "get_UpgradeState")
QDEF(MP_QSTR_get_UtcOffset, 21347, 13, "get_UtcOffset")
QDEF(MP_QSTR_get_VectTblOffset, 19839, 17, "get_VectTblOffset")
QDEF(MP_QSTR_get_VersionError, 59854, 16, "get_VersionError")
QDEF(MP_QSTR_get_VersionVoltage, 35828, 18, "get_VersionVoltage")
QDEF(MP_QSTR_get_WatchdogCount, 16426, 17, "get_WatchdogCount")
QDEF(MP_QSTR_get_Wheel1AbstractType, 5782, 22, "get_Wheel1AbstractType")
QDEF(MP_QSTR_get_Wheel1AbstractTypeError, 37166, 27, "get_Wheel1AbstractTypeError")
QDEF(MP_QSTR_get_Wheel1AddrAssignError, 34692, 25, "get_Wheel1AddrAssignError")
QDEF(MP_QSTR_get_Wheel1Address, 45272, 17, "get_Wheel1Address")
QDEF(MP_QSTR_get_Wheel1CommsError, 21417, 20, "get_Wheel1CommsError")
QDEF(MP_QSTR_get_Wheel1ErrorCode, 48731, 19, "get_Wheel1ErrorCode")
QDEF(MP_QSTR_get_Wheel1NodeType, 19766, 18, "get_Wheel1NodeType")
QDEF(MP_QSTR_get_Wheel1NodeTypeMatchError, 35773, 28, "get_Wheel1NodeTypeMatchError")
QDEF(MP_QSTR_get_Wheel1SerialInt, 29725, 19, "get_Wheel1SerialInt")
QDEF(MP_QSTR_get_Wheel1SerialMatchError, 37445, 26, "get_Wheel1SerialMatchError")
QDEF(MP_QSTR_get_Wheel1SerialResolveError, 5282, 28, "get_Wheel1SerialResolveError")
QDEF(MP_QSTR_get_Wheel1UnexpectedError, 6291, 25, "get_Wheel1UnexpectedError")
QDEF(MP_QSTR_get_Wheel2AbstractType, 30293, 22, "get_Wheel2AbstractType")
QDEF(MP_QSTR_get_Wheel2AbstractTypeError, 49293, 27, "get_Wheel2AbstractTypeError")
QDEF(MP_QSTR_get_Wheel2AddrAssignError, 57895, 25, "get_Wheel2AddrAssignError")
QDEF(MP_QSTR_get_Wheel2Address, 23291, 17, "get_Wheel2Address")
QDEF(MP_QSTR_get_Wheel2CommsError, 48874, 20, "get_Wheel2CommsError")
QDEF(MP_QSTR_get_Wheel2ErrorCode, 7352, 19, "get_Wheel2ErrorCode")
QDEF(MP_QSTR_get_Wheel2NodeType, 44213, 18, "get_Wheel2NodeType")
QDEF(MP_QSTR_get_Wheel2NodeTypeMatchError, 61182, 28, "get_Wheel2NodeTypeMatchError")
QDEF(MP_QSTR_get_Wheel2SerialInt, 8894, 19, "get_Wheel2SerialInt")
QDEF(MP_QSTR_get_Wheel2SerialMatchError, 32966, 26, "get_Wheel2SerialMatchError")
QDEF(MP_QSTR_get_Wheel2SerialResolveError, 23009, 28, "get_Wheel2SerialResolveError")
QDEF(MP_QSTR_get_Wheel2UnexpectedError, 50224, 25, "get_Wheel2UnexpectedError")
QDEF(MP_QSTR_get_Wheel3AbstractType, 10004, 22, "get_Wheel3AbstractType")
QDEF(MP_QSTR_get_Wheel3AbstractTypeError, 57836, 27, "get_Wheel3AbstractTypeError")
QDEF(MP_QSTR_get_Wheel3AddrAssignError, 32838, 25, "get_Wheel3AddrAssignError")
QDEF(MP_QSTR_get_Wheel3Address, 46874, 17, "get_Wheel3Address")
QDEF(MP_QSTR_get_Wheel3CommsError, 47531, 20, "get_Wheel3CommsError")
QDEF(MP_QSTR_get_Wheel3ErrorCode, 23833, 19, "get_Wheel3ErrorCode")
QDEF(MP_QSTR_get_Wheel3NodeType, 52148, 18, "get_Wheel3NodeType")
QDEF(MP_QSTR_get_Wheel3NodeTypeMatchError, 33087, 28, "get_Wheel3NodeTypeMatchError")
QDEF(MP_QSTR_get_Wheel3SerialInt, 41695, 19, "get_Wheel3SerialInt")
QDEF(MP_QSTR_get_Wheel3SerialMatchError, 61511, 26, "get_Wheel3SerialMatchError")
QDEF(MP_QSTR_get_Wheel3SerialResolveError, 19360, 28, "get_Wheel3SerialResolveError")
QDEF(MP_QSTR_get_Wheel3UnexpectedError, 37457, 25, "get_Wheel3UnexpectedError")
QDEF(MP_QSTR_get_Wheel4AbstractType, 10963, 22, "get_Wheel4AbstractType")
QDEF(MP_QSTR_get_Wheel4AbstractTypeError, 46667, 27, "get_Wheel4AbstractTypeError")
QDEF(MP_QSTR_get_Wheel4AddrAssignError, 47329, 25, "get_Wheel4AddrAssignError")
QDEF(MP_QSTR_get_Wheel4Address, 41533, 17, "get_Wheel4Address")
QDEF(MP_QSTR_get_Wheel4CommsError, 58604, 20, "get_Wheel4CommsError")
QDEF(MP_QSTR_get_Wheel4ErrorCode, 56958, 19, "get_Wheel4ErrorCode")
QDEF(MP_QSTR_get_Wheel4NodeType, 3891, 18, "get_Wheel4NodeType")
QDEF(MP_QSTR_get_Wheel4NodeTypeMatchError, 35192, 28, "get_Wheel4NodeTypeMatchError")
QDEF(MP_QSTR_get_Wheel4SerialInt, 62328, 19, "get_Wheel4SerialInt")
QDEF(MP_QSTR_get_Wheel4SerialMatchError, 448, 26, "get_Wheel4SerialMatchError")
QDEF(MP_QSTR_get_Wheel4SerialResolveError, 20967, 28, "get_Wheel4SerialResolveError")
QDEF(MP_QSTR_get_Wheel4UnexpectedError, 24054, 25, "get_Wheel4UnexpectedError")
QDEF(MP_QSTR_get_WriteError, 59529, 14, "get_WriteError")
QDEF(MP_QSTR_get_YawCompensate, 282, 17, "get_YawCompensate")
QDEF(MP_QSTR_get_acq_period_ms, 58436, 17, "get_acq_period_ms")
QDEF(MP_QSTR_get_active, 15584, 10, "get_active")
QDEF(MP_QSTR_get_active_file_cfg_type, 21987, 24, "get_active_file_cfg_type")
QDEF(MP_QSTR_get_active_preset_id, 2696, 20, "get_active_preset_id")
QDEF(MP_QSTR_get_active_slot_id, 8617, 18, "get_active_slot_id")
QDEF(MP_QSTR_get_adcsErrorCode, 59148, 17, "get_adcsErrorCode")
QDEF(MP_QSTR_get_adcs_config_validation_error, 319, 32, "get_adcs_config_validation_error")
QDEF(MP_QSTR_get_all_events, 17549, 14, "get_all_events")
QDEF(MP_QSTR_get_ang_vel_low, 58927, 15, "get_ang_vel_low")
QDEF(MP_QSTR_get_ang_vel_max, 59951, 15, "get_ang_vel_max")
QDEF(MP_QSTR_get_ang_vel_y_thom_high, 13234, 23, "get_ang_vel_y_thom_high")
QDEF(MP_QSTR_get_ang_vel_y_thom_low, 4296, 22, "get_ang_vel_y_thom_low")
QDEF(MP_QSTR_get_auto_discovery_error, 46865, 24, "get_auto_discovery_error")
QDEF(MP_QSTR_get_avail_presets_cnt, 2032, 21, "get_avail_presets_cnt")
QDEF(MP_QSTR_get_backup, 9858, 10, "get_backup")
QDEF(MP_QSTR_get_boot_status, 24273, 15, "get_boot_status")
QDEF(MP_QSTR_get_busyError, 25641, 13, "get_busyError")
QDEF(MP_QSTR_get_can1Init, 64139, 12, "get_can1Init")
QDEF(MP_QSTR_get_can2Init, 9032, 12, "get_can2Init")
QDEF(MP_QSTR_get_canCritical, 38891, 15, "get_canCritical")
QDEF(MP_QSTR_get_canInfo, 26894, 11, "get_canInfo")
QDEF(MP_QSTR_get_canTlmIdBitmask, 36531, 19, "get_canTlmIdBitmask")
QDEF(MP_QSTR_get_canTlmInterval, 5482, 18, "get_canTlmInterval")
QDEF(MP_QSTR_get_canWarnMajor, 31121, 16, "get_canWarnMajor")
QDEF(MP_QSTR_get_canWarnMinor, 35485, 16, "get_canWarnMinor")
QDEF(MP_QSTR_get_captureError, 30320, 16, "get_captureError")
QDEF(MP_QSTR_get_cfg, 28398, 7, "get_cfg")
QDEF(MP_QSTR_get_commitConfigTable, 41801, 21, "get_commitConfigTable")
QDEF(MP_QSTR_get_commitFileTable, 42053, 19, "get_commitFileTable")
QDEF(MP_QSTR_get_comp_err_codes, 20294, 18, "get_comp_err_codes")
QDEF(MP_QSTR_get_configInit, 46780, 14, "get_configInit")
QDEF(MP_QSTR_get_config_persist_error, 11716, 24, "get_config_persist_error")
QDEF(MP_QSTR_get_configuration_file_name, 9629, 27, "get_configuration_file_name")
QDEF(MP_QSTR_get_control_loop_critical, 54396, 25, "get_control_loop_critical")
QDEF(MP_QSTR_get_control_loop_failure, 31767, 24, "get_control_loop_failure")
QDEF(MP_QSTR_get_control_mode, 823, 16, "get_control_mode")
QDEF(MP_QSTR_get_control_program_file_name, 50273, 29, "get_control_program_file_name")
QDEF(MP_QSTR_get_core_args, 43791, 13, "get_core_args")
QDEF(MP_QSTR_get_dataRemain, 24416, 14, "get_dataRemain")
QDEF(MP_QSTR_get_data_id, 2350, 11, "get_data_id")
QDEF(MP_QSTR_get_detection_enabled, 62969, 21, "get_detection_enabled")
QDEF(MP_QSTR_get_discarded_messages_cnt, 64742, 26, "get_discarded_messages_cnt")
QDEF(MP_QSTR_get_en_get_acp_execution_telemetry, 30942, 34, "get_en_get_acp_execution_telemetry")
QDEF(MP_QSTR_get_en_get_backup_estimator_telemetry, 13630, 37, "get_en_get_backup_estimator_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_css_sensor_telemetry, 53879, 42, "get_en_get_calibrated_css_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_fss_sensor_telemetry, 19282, 42, "get_en_get_calibrated_fss_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_gnss_sensor_telemetry, 10461, 43, "get_en_get_calibrated_gnss_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_gyr_sensor_telemetry, 52632, 42, "get_en_get_calibrated_gyr_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_hss_sensor_telemetry, 49692, 42, "get_en_get_calibrated_hss_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_mag_sensor_telemetry, 39103, 42, "get_en_get_calibrated_mag_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_rwl_sensor_telemetry, 53885, 42, "get_en_get_calibrated_rwl_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_calibrated_str_sensor_telemetry, 13761, 42, "get_en_get_calibrated_str_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_controller_telemetry, 50493, 31, "get_en_get_controller_telemetry")
QDEF(MP_QSTR_get_en_get_cubecomputer_health, 8484, 30, "get_en_get_cubecomputer_health")
QDEF(MP_QSTR_get_en_get_health_telemetry_for_cubenode_nssrwl, 28239, 47, "get_en_get_health_telemetry_for_cubenode_nssrwl")
QDEF(MP_QSTR_get_en_get_health_telemetry_for_cubesense_earth, 38732, 47, "get_en_get_health_telemetry_for_cubesense_earth")
QDEF(MP_QSTR_get_en_get_health_telemetry_for_cubestar, 27491, 40, "get_en_get_health_telemetry_for_cubestar")
QDEF(MP_QSTR_get_en_get_health_telemetry_for_reaction_wheels, 27440, 47, "get_en_get_health_telemetry_for_reaction_wheels")
QDEF(MP_QSTR_get_en_get_health_tlm_for_cubemag_magnetometer, 60713, 46, "get_en_get_health_tlm_for_cubemag_magnetometer")
QDEF(MP_QSTR_get_en_get_health_tlm_for_cubenode_pst3s, 50821, 40, "get_en_get_health_tlm_for_cubenode_pst3s")
QDEF(MP_QSTR_get_en_get_health_tlm_for_cubesense_sun, 12596, 39, "get_en_get_health_tlm_for_cubesense_sun")
QDEF(MP_QSTR_get_en_get_main_estimator_high_resolution_telemetry, 34555, 51, "get_en_get_main_estimator_high_resolution_telemetry")
QDEF(MP_QSTR_get_en_get_main_estimator_telemetry, 49915, 35, "get_en_get_main_estimator_telemetry")
QDEF(MP_QSTR_get_en_get_models_telemetry, 43229, 27, "get_en_get_models_telemetry")
QDEF(MP_QSTR_get_en_get_raw_css_sensor_telemetry, 10960, 35, "get_en_get_raw_css_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_cubesense_earth_telemetry, 6640, 40, "get_en_get_raw_cubesense_earth_telemetry")
QDEF(MP_QSTR_get_en_get_raw_cubesense_sun_telemetry, 50930, 38, "get_en_get_raw_cubesense_sun_telemetry")
QDEF(MP_QSTR_get_en_get_raw_external_sensor_telemetry, 29838, 40, "get_en_get_raw_external_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_gnss_sensor_telemetry, 54042, 36, "get_en_get_raw_gnss_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_gyr_sensor_telemetry, 59071, 35, "get_en_get_raw_gyr_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_mag_sensor_telemetry, 5528, 35, "get_en_get_raw_mag_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_nssrwl_sensor_telemetry, 34196, 38, "get_en_get_raw_nssrwl_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_raw_pst3s_star_tracker_telemetry, 52769, 43, "get_en_get_raw_pst3s_star_tracker_telemetry")
QDEF(MP_QSTR_get_en_get_raw_rwl_sensor_telemetry, 41690, 35, "get_en_get_raw_rwl_sensor_telemetry")
QDEF(MP_QSTR_get_en_get_torquer_current_measurements, 20507, 39, "get_en_get_torquer_current_measurements")
QDEF(MP_QSTR_get_endTimeUnix, 13276, 15, "get_endTimeUnix")
QDEF(MP_QSTR_get_eraseError, 18420, 14, "get_eraseError")
QDEF(MP_QSTR_get_erasePage, 43935, 13, "get_erasePage")
QDEF(MP_QSTR_get_err, 18409, 7, "get_err")
QDEF(MP_QSTR_get_err_code, 51963, 12, "get_err_code")
QDEF(MP_QSTR_get_errorCode, 409, 13, "get_errorCode")
QDEF(MP_QSTR_get_errors, 15527, 10, "get_errors")
QDEF(MP_QSTR_get_estimation_mode, 32747, 19, "get_estimation_mode")
QDEF(MP_QSTR_get_estimation_mode_backup, 18906, 26, "get_estimation_mode_backup")
QDEF(MP_QSTR_get_estimation_mode_main, 53343, 24, "get_estimation_mode_main")
QDEF(MP_QSTR_get_eventClass, 45582, 14, "get_eventClass")
QDEF(MP_QSTR_get_eventData, 7440, 13, "get_eventData")
QDEF(MP_QSTR_get_eventSource, 11133, 15, "get_eventSource")
QDEF(MP_QSTR_get_eventType, 49560, 13, "get_eventType")
QDEF(MP_QSTR_get_event_fdir_execution_num, 53794, 28, "get_event_fdir_execution_num")
QDEF(MP_QSTR_get_event_fdir_execution_res, 32304, 28, "get_event_fdir_execution_res")
QDEF(MP_QSTR_get_event_type, 62183, 14, "get_event_type")
QDEF(MP_QSTR_get_extGyro0, 64662, 12, "get_extGyro0")
QDEF(MP_QSTR_get_extGyro1, 64663, 12, "get_extGyro1")
QDEF(MP_QSTR_get_extSensor0, 27587, 14, "get_extSensor0")
QDEF(MP_QSTR_get_extSensor1, 27586, 14, "get_extSensor1")
QDEF(MP_QSTR_get_fastBitMask, 58983, 15, "get_fastBitMask")
QDEF(MP_QSTR_get_fault_id, 30772, 12, "get_fault_id")
QDEF(MP_QSTR_get_fdir_level, 380, 14, "get_fdir_level")
QDEF(MP_QSTR_get_fdir_level_set, 21953, 18, "get_fdir_level_set")
QDEF(MP_QSTR_get_fdir_logic, 64484, 14, "get_fdir_logic")
QDEF(MP_QSTR_get_fileCrc, 16216, 11, "get_fileCrc")
QDEF(MP_QSTR_get_fileCrcError, 34080, 16, "get_fileCrcError")
QDEF(MP_QSTR_get_fileEmptyError, 46247, 18, "get_fileEmptyError")
QDEF(MP_QSTR_get_fileError, 31154, 13, "get_fileError")
QDEF(MP_QSTR_get_fileFullError, 29985, 17, "get_fileFullError")
QDEF(MP_QSTR_get_fileInvalidError, 21699, 20, "get_fileInvalidError")
QDEF(MP_QSTR_get_fileMetaError, 60431, 17, "get_fileMetaError")
QDEF(MP_QSTR_get_fileOpenReadError, 8980, 21, "get_fileOpenReadError")
QDEF(MP_QSTR_get_fileOpenWriteError, 50363, 22, "get_fileOpenWriteError")
QDEF(MP_QSTR_get_fileReadError, 9056, 17, "get_fileReadError")
QDEF(MP_QSTR_get_fileSizeError, 29719, 17, "get_fileSizeError")
QDEF(MP_QSTR_get_fileWriteError, 21199, 18, "get_fileWriteError")
QDEF(MP_QSTR_get_file_name, 6962, 13, "get_file_name")
QDEF(MP_QSTR_get_filterType, 63124, 14, "get_filterType")
QDEF(MP_QSTR_get_flags, 4499, 9, "get_flags")
QDEF(MP_QSTR_get_flashInit, 30502, 13, "get_flashInit")
QDEF(MP_QSTR_get_force, 54833, 9, "get_force")
QDEF(MP_QSTR_get_frameSizeError, 65004, 18, "get_frameSizeError")
QDEF(MP_QSTR_get_free_bytes_min, 11595, 18, "get_free_bytes_min")
QDEF(MP_QSTR_get_fss0, 44218, 8, "get_fss0")
QDEF(MP_QSTR_get_fss1, 44219, 8, "get_fss1")
QDEF(MP_QSTR_get_fss2, 44216, 8, "get_fss2")
QDEF(MP_QSTR_get_fss3, 44217, 8, "get_fss3")
QDEF(MP_QSTR_get_ftp_state, 31014, 13, "get_ftp_state")
QDEF(MP_QSTR_get_gyro0, 11583, 9, "get_gyro0")
QDEF(MP_QSTR_get_gyro1, 11582, 9, "get_gyro1")
QDEF(MP_QSTR_get_gyro_critical, 25563, 17, "get_gyro_critical")
QDEF(MP_QSTR_get_gyro_voltage_error, 725, 22, "get_gyro_voltage_error")
QDEF(MP_QSTR_get_halInit, 56307, 11, "get_halInit")
QDEF(MP_QSTR_get_hss0, 37748, 8, "get_hss0")
QDEF(MP_QSTR_get_hss1, 37749, 8, "get_hss1")
QDEF(MP_QSTR_get_i2cInit, 60046, 11, "get_i2cInit")
QDEF(MP_QSTR_get_includeClassCritical, 41717, 24, "get_includeClassCritical")
QDEF(MP_QSTR_get_includeClassInfo, 49936, 20, "get_includeClassInfo")
QDEF(MP_QSTR_get_includeClassMajorWarning, 39119, 28, "get_includeClassMajorWarning")
QDEF(MP_QSTR_get_includeClassMinorWarning, 64835, 28, "get_includeClassMinorWarning")
QDEF(MP_QSTR_get_includeSourceCubeComputer, 63451, 29, "get_includeSourceCubeComputer")
QDEF(MP_QSTR_get_includeSourceExt0, 51892, 21, "get_includeSourceExt0")
QDEF(MP_QSTR_get_includeSourceExt1, 51893, 21, "get_includeSourceExt1")
QDEF(MP_QSTR_get_includeSourceFss0, 27899, 21, "get_includeSourceFss0")
QDEF(MP_QSTR_get_includeSourceFss1, 27898, 21, "get_includeSourceFss1")
QDEF(MP_QSTR_get_includeSourceFss2, 27897, 21, "get_includeSourceFss2")
QDEF(MP_QSTR_get_includeSourceFss3, 27896, 21, "get_includeSourceFss3")
QDEF(MP_QSTR_get_includeSourceHss0, 21429, 21, "get_includeSourceHss0")
QDEF(MP_QSTR_get_includeSourceHss1, 21428, 21, "get_includeSourceHss1")
QDEF(MP_QSTR_get_includeSourceMag0, 25750, 21, "get_includeSourceMag0")
QDEF(MP_QSTR_get_includeSourceMag1, 25751, 21, "get_includeSourceMag1")
QDEF(MP_QSTR_get_includeSourceRwl0, 52308, 21, "get_includeSourceRwl0")
QDEF(MP_QSTR_get_includeSourceRwl1, 52309, 21, "get_includeSourceRwl1")
QDEF(MP_QSTR_get_includeSourceRwl2, 52310, 21, "get_includeSourceRwl2")
QDEF(MP_QSTR_get_includeSourceRwl3, 52311, 21, "get_includeSourceRwl3")
QDEF(MP_QSTR_get_includeSourceStr0, 18088, 21, "get_includeSourceStr0")
QDEF(MP_QSTR_get_includeSourceStr1, 18089, 21, "get_includeSourceStr1")
QDEF(MP_QSTR_get_info, 58210, 8, "get_info")
QDEF(MP_QSTR_get_invalidNodeError, 61573, 20, "get_invalidNodeError")
QDEF(MP_QSTR_get_is_active, 31877, 13, "get_is_active")
QDEF(MP_QSTR_get_is_started, 33928, 14, "get_is_started")
QDEF(MP_QSTR_get_is_valid, 64831, 12, "get_is_valid")
QDEF(MP_QSTR_get_jumpTarget, 56639, 14, "get_jumpTarget")
QDEF(MP_QSTR_get_last_error_code, 31635, 19, "get_last_error_code")
QDEF(MP_QSTR_get_latestEntryUnix, 30953, 19, "get_latestEntryUnix")
QDEF(MP_QSTR_get_logIdBitmask, 61262, 16, "get_logIdBitmask")
QDEF(MP_QSTR_get_mag0, 35863, 8, "get_mag0")
QDEF(MP_QSTR_get_mag1, 35862, 8, "get_mag1")
QDEF(MP_QSTR_get_mag_deploy_error, 9268, 20, "get_mag_deploy_error")
QDEF(MP_QSTR_get_magicNumber, 46542, 15, "get_magicNumber")
QDEF(MP_QSTR_get_main, 35847, 8, "get_main")
QDEF(MP_QSTR_get_mask_0, 22871, 10, "get_mask_0")
QDEF(MP_QSTR_get_mask_1, 22870, 10, "get_mask_1")
QDEF(MP_QSTR_get_mask_2, 22869, 10, "get_mask_2")
QDEF(MP_QSTR_get_mask_3, 22868, 10, "get_mask_3")
QDEF(MP_QSTR_get_mask_4, 22867, 10, "get_mask_4")
QDEF(MP_QSTR_get_max_log_files_cnt, 30895, 21, "get_max_log_files_cnt")
QDEF(MP_QSTR_get_max_number_of_batch_msg, 55447, 27, "get_max_number_of_batch_msg")
QDEF(MP_QSTR_get_max_tlm_msg_cnt, 63410, 19, "get_max_tlm_msg_cnt")
QDEF(MP_QSTR_get_mode, 46511, 8, "get_mode")
QDEF(MP_QSTR_get_msg_popped_cnt, 62226, 18, "get_msg_popped_cnt")
QDEF(MP_QSTR_get_msg_pushed_cnt, 59507, 18, "get_msg_pushed_cnt")
QDEF(MP_QSTR_get_name, 171, 8, "get_name")
QDEF(MP_QSTR_get_nodeCommsError, 33355, 18, "get_nodeCommsError")
QDEF(MP_QSTR_get_nodeExistError, 22887, 18, "get_nodeExistError")
QDEF(MP_QSTR_get_nodeExpectError, 58155, 19, "get_nodeExpectError")
QDEF(MP_QSTR_get_nodeUsedError, 14963, 17, "get_nodeUsedError")
QDEF(MP_QSTR_get_node_comm_error, 45880, 19, "get_node_comm_error")
QDEF(MP_QSTR_get_node_failure, 12339, 16, "get_node_failure")
QDEF(MP_QSTR_get_node_jump_error, 40342, 19, "get_node_jump_error")
QDEF(MP_QSTR_get_node_setup_error, 55283, 20, "get_node_setup_error")
QDEF(MP_QSTR_get_node_type, 51403, 13, "get_node_type")
QDEF(MP_QSTR_get_nodes_pwr_states, 61966, 20, "get_nodes_pwr_states")
QDEF(MP_QSTR_get_numEntries, 16488, 14, "get_numEntries")
QDEF(MP_QSTR_get_numberOfCriticalEvents, 57746, 26, "get_numberOfCriticalEvents")
QDEF(MP_QSTR_get_numberOfEmptyEntries, 48929, 24, "get_numberOfEmptyEntries")
QDEF(MP_QSTR_get_numberOfEntries, 59828, 19, "get_numberOfEntries")
QDEF(MP_QSTR_get_numberOfEntriesBuffered, 4373, 27, "get_numberOfEntriesBuffered")
QDEF(MP_QSTR_get_numberOfEntriesQueued, 43553, 25, "get_numberOfEntriesQueued")
QDEF(MP_QSTR_get_numberOfInfoEvents, 55223, 22, "get_numberOfInfoEvents")
QDEF(MP_QSTR_get_numberOfMajorWarningEvents, 41768, 30, "get_numberOfMajorWarningEvents")
QDEF(MP_QSTR_get_numberOfMinorWarningEvents, 37284, 30, "get_numberOfMinorWarningEvents")
QDEF(MP_QSTR_get_numberOfTlmIterations, 29559, 25, "get_numberOfTlmIterations")
QDEF(MP_QSTR_get_obc_file, 53691, 12, "get_obc_file")
QDEF(MP_QSTR_get_oldestEntryUnix, 49431, 19, "get_oldestEntryUnix")
QDEF(MP_QSTR_get_opResult, 42106, 12, "get_opResult")
QDEF(MP_QSTR_get_op_mode, 54255, 11, "get_op_mode")
QDEF(MP_QSTR_get_op_result, 24997, 13, "get_op_result")
QDEF(MP_QSTR_get_op_state, 65275, 12, "get_op_state")
QDEF(MP_QSTR_get_op_status_app, 26406, 17, "get_op_status_app")
QDEF(MP_QSTR_get_op_status_common, 47434, 20, "get_op_status_common")
QDEF(MP_QSTR_get_overrun, 39691, 11, "get_overrun")
QDEF(MP_QSTR_get_params, 30192, 10, "get_params")
QDEF(MP_QSTR_get_pl_args, 53960, 11, "get_pl_args")
QDEF(MP_QSTR_get_pl_state, 64280, 12, "get_pl_state")
QDEF(MP_QSTR_get_port_validation_error, 1190, 25, "get_port_validation_error")
QDEF(MP_QSTR_get_power_state, 6075, 15, "get_power_state")
QDEF(MP_QSTR_get_readError, 43846, 13, "get_readError")
QDEF(MP_QSTR_get_readQueueState, 58904, 18, "get_readQueueState")
QDEF(MP_QSTR_get_refParam1, 3715, 13, "get_refParam1")
QDEF(MP_QSTR_get_refParam2, 3712, 13, "get_refParam2")
QDEF(MP_QSTR_get_refParam3, 3713, 13, "get_refParam3")
QDEF(MP_QSTR_get_ref_param1, 16476, 14, "get_ref_param1")
QDEF(MP_QSTR_get_ref_param2, 16479, 14, "get_ref_param2")
QDEF(MP_QSTR_get_ref_param3, 16478, 14, "get_ref_param3")
QDEF(MP_QSTR_get_ref_params, 16414, 14, "get_ref_params")
QDEF(MP_QSTR_get_req_state_id, 15088, 16, "get_req_state_id")
QDEF(MP_QSTR_get_res, 38280, 7, "get_res")
QDEF(MP_QSTR_get_reserved_0, 31431, 14, "get_reserved_0")
QDEF(MP_QSTR_get_reserved_1, 31430, 14, "get_reserved_1")
QDEF(MP_QSTR_get_reserved_2, 31429, 14, "get_reserved_2")
QDEF(MP_QSTR_get_reserved_3, 31428, 14, "get_reserved_3")
QDEF(MP_QSTR_get_reserved_4, 31427, 14, "get_reserved_4")
QDEF(MP_QSTR_get_reserved_5, 31426, 14, "get_reserved_5")
QDEF(MP_QSTR_get_reserved_6, 31425, 14, "get_reserved_6")
QDEF(MP_QSTR_get_result, 1381, 10, "get_result")
QDEF(MP_QSTR_get_returnVal, 43069, 13, "get_returnVal")
QDEF(MP_QSTR_get_run_mode, 8537, 12, "get_run_mode")
QDEF(MP_QSTR_get_rwl0, 3157, 8, "get_rwl0")
QDEF(MP_QSTR_get_rwl1, 3156, 8, "get_rwl1")
QDEF(MP_QSTR_get_rwl2, 3159, 8, "get_rwl2")
QDEF(MP_QSTR_get_rwl3, 3158, 8, "get_rwl3")
QDEF(MP_QSTR_get_sdr_file, 44496, 12, "get_sdr_file")
QDEF(MP_QSTR_get_serial_int, 47296, 14, "get_serial_int")
QDEF(MP_QSTR_get_set_control_mode, 24746, 20, "get_set_control_mode")
QDEF(MP_QSTR_get_set_is_allowed, 53612, 18, "get_set_is_allowed")
QDEF(MP_QSTR_get_setup, 44075, 9, "get_setup")
QDEF(MP_QSTR_get_setupError, 57523, 14, "get_setupError")
QDEF(MP_QSTR_get_size_limit_cfg, 40382, 18, "get_size_limit_cfg")
QDEF(MP_QSTR_get_size_limit_kb, 50613, 17, "get_size_limit_kb")
QDEF(MP_QSTR_get_slot_preset_cnt, 40148, 19, "get_slot_preset_cnt")
QDEF(MP_QSTR_get_slowBitMask, 43552, 15, "get_slowBitMask")
QDEF(MP_QSTR_get_sm_state, 61178, 12, "get_sm_state")
QDEF(MP_QSTR_get_startTimeUnix, 63635, 17, "get_startTimeUnix")
QDEF(MP_QSTR_get_status, 40696, 10, "get_status")
QDEF(MP_QSTR_get_str0, 51177, 8, "get_str0")
QDEF(MP_QSTR_get_str1, 51176, 8, "get_str1")
QDEF(MP_QSTR_get_sys_states_cfg, 52435, 18, "get_sys_states_cfg")
QDEF(MP_QSTR_get_t_batt_safe_lower, 8022, 21, "get_t_batt_safe_lower")
QDEF(MP_QSTR_get_t_batt_safe_upper, 25527, 21, "get_t_batt_safe_upper")
QDEF(MP_QSTR_get_telemetry_stats, 24413, 19, "get_telemetry_stats")
QDEF(MP_QSTR_get_thresh_vals, 14315, 15, "get_thresh_vals")
QDEF(MP_QSTR_get_thresh_value, 13800, 16, "get_thresh_value")
QDEF(MP_QSTR_get_timeout, 50903, 11, "get_timeout")
QDEF(MP_QSTR_get_timeoutError, 45519, 16, "get_timeoutError")
QDEF(MP_QSTR_get_tlmLogReturnInterval, 13800, 24, "get_tlmLogReturnInterval")
QDEF(MP_QSTR_get_tlm_auto_start_en, 21442, 21, "get_tlm_auto_start_en")
QDEF(MP_QSTR_get_transferSize, 24994, 16, "get_transferSize")
QDEF(MP_QSTR_get_transfer_state, 58479, 18, "get_transfer_state")
QDEF(MP_QSTR_get_uart1Init, 13941, 13, "get_uart1Init")
QDEF(MP_QSTR_get_uart2Critical, 39, 17, "get_uart2Critical")
QDEF(MP_QSTR_get_uart2Info, 12098, 13, "get_uart2Info")
QDEF(MP_QSTR_get_uart2Init, 11702, 13, "get_uart2Init")
QDEF(MP_QSTR_get_uart2TlmIdBitmask, 12543, 21, "get_uart2TlmIdBitmask")
QDEF(MP_QSTR_get_uart2TlmInterval, 47014, 20, "get_uart2TlmInterval")
QDEF(MP_QSTR_get_uart2WarnMajor, 51421, 18, "get_uart2WarnMajor")
QDEF(MP_QSTR_get_uart2WarnMinor, 47057, 18, "get_uart2WarnMinor")
QDEF(MP_QSTR_get_uartCritical, 213, 16, "get_uartCritical")
QDEF(MP_QSTR_get_uartInfo, 49392, 12, "get_uartInfo")
QDEF(MP_QSTR_get_uartTlmIdBitmask, 53645, 20, "get_uartTlmIdBitmask")
QDEF(MP_QSTR_get_uartTlmInterval, 49940, 19, "get_uartTlmInterval")
QDEF(MP_QSTR_get_uartWarnMajor, 24239, 17, "get_uartWarnMajor")
QDEF(MP_QSTR_get_uartWarnMinor, 19875, 17, "get_uartWarnMinor")
QDEF(MP_QSTR_get_upgradeState, 48427, 16, "get_upgradeState")
QDEF(MP_QSTR_get_v5Sense, 41505, 11, "get_v5Sense")
QDEF(MP_QSTR_get_v_batt_safe, 61448, 15, "get_v_batt_safe")
QDEF(MP_QSTR_get_versionError, 19566, 16, "get_versionError")
QDEF(MP_QSTR_get_virtual_watchdog_error, 39472, 26, "get_virtual_watchdog_error")
QDEF(MP_QSTR_get_virtual_watchdog_warning, 31266, 28, "get_virtual_watchdog_warning")
QDEF(MP_QSTR_get_wSunYawRef, 4045, 14, "get_wSunYawRef")
QDEF(MP_QSTR_get_write, 12017, 9, "get_write")
QDEF(MP_QSTR_get_writeCounter, 19845, 16, "get_writeCounter")
QDEF(MP_QSTR_get_writeError, 3625, 14, "get_writeError")
QDEF(MP_QSTR_get_wy_ref, 8716, 10, "get_wy_ref")
QDEF(MP_QSTR_getcwd, 53251, 6, "getcwd")
QDEF(MP_QSTR_getter, 45712, 6, "getter")
QDEF(MP_QSTR_getvalue, 44152, 8, "getvalue")
QDEF(MP_QSTR_gmtime, 36442, 6, "gmtime")
QDEF(MP_QSTR_heap_lock, 36013, 9, "heap_lock")
QDEF(MP_QSTR_heap_unlock, 11606, 11, "heap_unlock")
QDEF(MP_QSTR_help, 23700, 4, "help")
QDEF(MP_QSTR_hex, 20592, 3, "hex")
QDEF(MP_QSTR_ilistdir, 27249, 8, "ilistdir")
QDEF(MP_QSTR_imag, 46919, 4, "imag")
QDEF(MP_QSTR_implementation, 11543, 14, "implementation")
QDEF(MP_QSTR_intersection, 10792, 12, "intersection")
QDEF(MP_QSTR_intersection_update, 56582, 19, "intersection_update")
QDEF(MP_QSTR_io, 28451, 2, "io")
QDEF(MP_QSTR_ioctl, 49784, 5, "ioctl")
QDEF(MP_QSTR_isdisjoint, 26871, 10, "isdisjoint")
QDEF(MP_QSTR_isenabled, 58778, 9, "isenabled")
QDEF(MP_QSTR_isfinite, 43942, 8, "isfinite")
QDEF(MP_QSTR_isinf, 4414, 5, "isinf")
QDEF(MP_QSTR_isnan, 926, 5, "isnan")
QDEF(MP_QSTR_issubset, 49593, 8, "issubset")
QDEF(MP_QSTR_issuperset, 60668, 10, "issuperset")
QDEF(MP_QSTR_iterable, 37413, 8, "iterable")
QDEF(MP_QSTR_iterator, 48711, 8, "iterator")
QDEF(MP_QSTR_ldexp, 28480, 5, "ldexp")
QDEF(MP_QSTR_listdir, 58264, 7, "listdir")
QDEF(MP_QSTR_localtime, 18045, 9, "localtime")
QDEF(MP_QSTR_log, 16161, 3, "log")
QDEF(MP_QSTR_math, 47925, 4, "math")
QDEF(MP_QSTR_max, 17329, 3, "max")
QDEF(MP_QSTR_mem_alloc, 11090, 9, "mem_alloc")
QDEF(MP_QSTR_mem_free, 25291, 8, "mem_free")
QDEF(MP_QSTR_min, 17071, 3, "min")
QDEF(MP_QSTR_mkdir, 46492, 5, "mkdir")
QDEF(MP_QSTR_mkfs, 45174, 4, "mkfs")
QDEF(MP_QSTR_mktime, 11158, 6, "mktime")
QDEF(MP_QSTR_mode, 49190, 4, "mode")
QDEF(MP_QSTR_modf, 49189, 4, "modf")
QDEF(MP_QSTR_module, 39359, 6, "module")
QDEF(MP_QSTR_modules, 53740, 7, "modules")
QDEF(MP_QSTR_mount, 3496, 5, "mount")
QDEF(MP_QSTR_name, 30114, 4, "name")
QDEF(MP_QSTR_namedtuple, 5662, 10, "namedtuple")
QDEF(MP_QSTR_obc_comm_gw, 34903, 11, "obc_comm_gw")
QDEF(MP_QSTR_oct, 23805, 3, "oct")
QDEF(MP_QSTR_pack, 53692, 4, "pack")
QDEF(MP_QSTR_pack_into, 43295, 9, "pack_into")
QDEF(MP_QSTR_path, 52872, 4, "path")
QDEF(MP_QSTR_pend_throw, 29939, 10, "pend_throw")
QDEF(MP_QSTR_pi, 28700, 2, "pi")
QDEF(MP_QSTR_preview, 54767, 7, "preview")
QDEF(MP_QSTR_print_exception, 8732, 15, "print_exception")
QDEF(MP_QSTR_property, 10690, 8, "property")
QDEF(MP_QSTR_r, 46551, 1, "r")
QDEF(MP_QSTR_radians, 16263, 7, "radians")
QDEF(MP_QSTR_rb, 28885, 2, "rb")
QDEF(MP_QSTR_readblocks, 7213, 10, "readblocks")
QDEF(MP_QSTR_readlines, 22890, 9, "readlines")
QDEF(MP_QSTR_readonly, 35075, 8, "readonly")
QDEF(MP_QSTR_real, 63935, 4, "real")
QDEF(MP_QSTR_rename, 6197, 6, "rename")
QDEF(MP_QSTR_req_cleanTelemetryFiles, 53827, 23, "req_cleanTelemetryFiles")
QDEF(MP_QSTR_req_clear_events_since_last_power_up, 11847, 36, "req_clear_events_since_last_power_up")
QDEF(MP_QSTR_req_clear_fdir_persistent_errors, 38413, 32, "req_clear_fdir_persistent_errors")
QDEF(MP_QSTR_req_clear_fdir_stats, 38045, 20, "req_clear_fdir_stats")
QDEF(MP_QSTR_req_download_evt, 37264, 16, "req_download_evt")
QDEF(MP_QSTR_req_download_evt_status, 9147, 23, "req_download_evt_status")
QDEF(MP_QSTR_req_download_img_direct, 62086, 23, "req_download_img_direct")
QDEF(MP_QSTR_req_download_img_direct_status, 37229, 30, "req_download_img_direct_status")
QDEF(MP_QSTR_req_download_tlm, 19778, 16, "req_download_tlm")
QDEF(MP_QSTR_req_download_tlm_status, 45353, 23, "req_download_tlm_status")
QDEF(MP_QSTR_req_force_clear_all_faults, 55007, 26, "req_force_clear_all_faults")
QDEF(MP_QSTR_req_force_clear_fault, 59506, 21, "req_force_clear_fault")
QDEF(MP_QSTR_req_fw_update_cube_computer, 11253, 27, "req_fw_update_cube_computer")
QDEF(MP_QSTR_req_fw_update_cube_computer_status, 32894, 34, "req_fw_update_cube_computer_status")
QDEF(MP_QSTR_req_fw_update_cube_node, 53426, 23, "req_fw_update_cube_node")
QDEF(MP_QSTR_req_fw_update_cube_node_status, 57113, 30, "req_fw_update_cube_node_status")
QDEF(MP_QSTR_req_getActivePreset, 63907, 19, "req_getActivePreset")
QDEF(MP_QSTR_req_getAdcsOpState, 24375, 18, "req_getAdcsOpState")
QDEF(MP_QSTR_req_getAdcsRunMode, 29301, 18, "req_getAdcsRunMode")
QDEF(MP_QSTR_req_getComponentErrorCodes, 195, 26, "req_getComponentErrorCodes")
QDEF(MP_QSTR_req_getConMode, 5419, 14, "req_getConMode")
QDEF(MP_QSTR_req_getConfigActuatorMtq, 59011, 24, "req_getConfigActuatorMtq")
QDEF(MP_QSTR_req_getConfigActuatorRwl, 15714, 24, "req_getConfigActuatorRwl")
QDEF(MP_QSTR_req_getConfigAdcsController, 53417, 27, "req_getConfigAdcsController")
QDEF(MP_QSTR_req_getConfigAdcsEstimator, 56315, 26, "req_getConfigAdcsEstimator")
QDEF(MP_QSTR_req_getConfigAdcsSatellite, 63470, 26, "req_getConfigAdcsSatellite")
QDEF(MP_QSTR_req_getConfigAsgp4, 465, 18, "req_getConfigAsgp4")
QDEF(MP_QSTR_req_getConfigDefaultModes, 38811, 25, "req_getConfigDefaultModes")
QDEF(MP_QSTR_req_getConfigMag0OrbitCal, 63127, 25, "req_getConfigMag0OrbitCal")
QDEF(MP_QSTR_req_getConfigMag1OrbitCal, 4054, 25, "req_getConfigMag1OrbitCal")
QDEF(MP_QSTR_req_getConfigMagSensingElement, 29022, 30, "req_getConfigMagSensingElement")
QDEF(MP_QSTR_req_getConfigMount, 3021, 18, "req_getConfigMount")
QDEF(MP_QSTR_req_getConfigNodeSelection, 17824, 26, "req_getConfigNodeSelection")
QDEF(MP_QSTR_req_getConfigOrbitSatParams, 2616, 27, "req_getConfigOrbitSatParams")
QDEF(MP_QSTR_req_getConfigOrbitTargetParams, 16399, 30, "req_getConfigOrbitTargetParams")
QDEF(MP_QSTR_req_getCubeNodePortMap, 15934, 22, "req_getCubeNodePortMap")
QDEF(MP_QSTR_req_getEstMode, 41003, 14, "req_getEstMode")
QDEF(MP_QSTR_req_getEventLogStatus, 57526, 21, "req_getEventLogStatus")
QDEF(MP_QSTR_req_getExpectedNodes, 18631, 20, "req_getExpectedNodes")
QDEF(MP_QSTR_req_getFileInfo, 46306, 15, "req_getFileInfo")
QDEF(MP_QSTR_req_getFileTransferSetup, 49024, 24, "req_getFileTransferSetup")
QDEF(MP_QSTR_req_getFileTransferStatus, 64755, 25, "req_getFileTransferStatus")
QDEF(MP_QSTR_req_getImageFileInfo, 59557, 20, "req_getImageFileInfo")
QDEF(MP_QSTR_req_getImageTransferStatus, 4370, 26, "req_getImageTransferStatus")
QDEF(MP_QSTR_req_getOpStatus, 60929, 15, "req_getOpStatus")
QDEF(MP_QSTR_req_getOpenLoopCommandHxyzRW, 7027, 28, "req_getOpenLoopCommandHxyzRW")
QDEF(MP_QSTR_req_getOpenLoopCommandMtq, 23373, 25, "req_getOpenLoopCommandMtq")
QDEF(MP_QSTR_req_getOpenLoopCommandRwl, 40364, 25, "req_getOpenLoopCommandRwl")
QDEF(MP_QSTR_req_getOrbMode, 17878, 14, "req_getOrbMode")
QDEF(MP_QSTR_req_getPassThrough, 4320, 18, "req_getPassThrough")
QDEF(MP_QSTR_req_getPortDiagnostics, 29831, 22, "req_getPortDiagnostics")
QDEF(MP_QSTR_req_getPortMap, 27631, 14, "req_getPortMap")
QDEF(MP_QSTR_req_getPowerState, 7906, 17, "req_getPowerState")
QDEF(MP_QSTR_req_getReferenceFmcParam, 58918, 24, "req_getReferenceFmcParam")
QDEF(MP_QSTR_req_getReferenceIrcVector, 5440, 25, "req_getReferenceIrcVector")
QDEF(MP_QSTR_req_getReferenceRpy, 55482, 19, "req_getReferenceRpy")
QDEF(MP_QSTR_req_getReferenceTarget, 46224, 22, "req_getReferenceTarget")
QDEF(MP_QSTR_req_getSimSensorRaw, 13519, 19, "req_getSimSensorRaw")
QDEF(MP_QSTR_req_getStateMachineState, 62927, 24, "req_getStateMachineState")
QDEF(MP_QSTR_req_getTelemetryFileSinkConfig, 34102, 30, "req_getTelemetryFileSinkConfig")
QDEF(MP_QSTR_req_getTelemetryGeneralConfig, 10521, 29, "req_getTelemetryGeneralConfig")
QDEF(MP_QSTR_req_getTelemetryOperationStats, 5297, 30, "req_getTelemetryOperationStats")
QDEF(MP_QSTR_req_getTelemetryPresetConfig, 27434, 28, "req_getTelemetryPresetConfig")
QDEF(MP_QSTR_req_getTelemtryLogInclusionMasks, 6501, 32, "req_getTelemtryLogInclusionMasks")
QDEF(MP_QSTR_req_getTelemtryLogStatus, 7344, 24, "req_getTelemtryLogStatus")
QDEF(MP_QSTR_req_getTlmAcpExecution, 3263, 22, "req_getTlmAcpExecution")
QDEF(MP_QSTR_req_getTlmAsgp4, 16910, 15, "req_getTlmAsgp4")
QDEF(MP_QSTR_req_getTlmController, 48163, 20, "req_getTlmController")
QDEF(MP_QSTR_req_getTlmCubeComputerHealth, 27317, 28, "req_getTlmCubeComputerHealth")
QDEF(MP_QSTR_req_getTlmCubeMagHealth, 57785, 23, "req_getTlmCubeMagHealth")
QDEF(MP_QSTR_req_getTlmEstimatorBackup, 60191, 25, "req_getTlmEstimatorBackup")
QDEF(MP_QSTR_req_getTlmEstimatorMain, 39578, 23, "req_getTlmEstimatorMain")
QDEF(MP_QSTR_req_getTlmEstimatorMainHighRes, 52912, 30, "req_getTlmEstimatorMainHighRes")
QDEF(MP_QSTR_req_getTlmExecutionPoint, 60065, 24, "req_getTlmExecutionPoint")
QDEF(MP_QSTR_req_getTlmExtSensorRaw, 12132, 22, "req_getTlmExtSensorRaw")
QDEF(MP_QSTR_req_getTlmFssCubeSenseSunHealth, 50738, 31, "req_getTlmFssCubeSenseSunHealth")
QDEF(MP_QSTR_req_getTlmFssCubeSenseSunRaw, 27658, 28, "req_getTlmFssCubeSenseSunRaw")
QDEF(MP_QSTR_req_getTlmGnssRaw, 2898, 17, "req_getTlmGnssRaw")
QDEF(MP_QSTR_req_getTlmGnssUartStatus, 48112, 24, "req_getTlmGnssUartStatus")
QDEF(MP_QSTR_req_getTlmGyrLitefuforsRaw, 45144, 26, "req_getTlmGyrLitefuforsRaw")
QDEF(MP_QSTR_req_getTlmHil, 46930, 13, "req_getTlmHil")
QDEF(MP_QSTR_req_getTlmHssCubeSenseEarthHealth, 27070, 33, "req_getTlmHssCubeSenseEarthHealth")
QDEF(MP_QSTR_req_getTlmHssCubeSenseEarthRaw, 6918, 30, "req_getTlmHssCubeSenseEarthRaw")
QDEF(MP_QSTR_req_getTlmLitefuforsHealth, 29612, 26, "req_getTlmLitefuforsHealth")
QDEF(MP_QSTR_req_getTlmModels, 26115, 16, "req_getTlmModels")
QDEF(MP_QSTR_req_getTlmNodeInitState, 30514, 23, "req_getTlmNodeInitState")
QDEF(MP_QSTR_req_getTlmNssRwlHealth, 27140, 22, "req_getTlmNssRwlHealth")
QDEF(MP_QSTR_req_getTlmRwlHealth, 29002, 19, "req_getTlmRwlHealth")
QDEF(MP_QSTR_req_getTlmRwlNssRwlRaw, 37397, 22, "req_getTlmRwlNssRwlRaw")
QDEF(MP_QSTR_req_getTlmSensorCalCss, 22820, 22, "req_getTlmSensorCalCss")
QDEF(MP_QSTR_req_getTlmSensorCalFss, 17505, 22, "req_getTlmSensorCalFss")
QDEF(MP_QSTR_req_getTlmSensorCalGnss, 17166, 23, "req_getTlmSensorCalGnss")
QDEF(MP_QSTR_req_getTlmSensorCalGyro, 30372, 23, "req_getTlmSensorCalGyro")
QDEF(MP_QSTR_req_getTlmSensorCalHss, 28399, 22, "req_getTlmSensorCalHss")
QDEF(MP_QSTR_req_getTlmSensorCalMag, 24684, 22, "req_getTlmSensorCalMag")
QDEF(MP_QSTR_req_getTlmSensorCalRwl, 38126, 22, "req_getTlmSensorCalRwl")
QDEF(MP_QSTR_req_getTlmSensorCalStr, 38930, 22, "req_getTlmSensorCalStr")
QDEF(MP_QSTR_req_getTlmSensorRawCss, 39598, 22, "req_getTlmSensorRawCss")
QDEF(MP_QSTR_req_getTlmSensorRawGyro, 46574, 23, "req_getTlmSensorRawGyro")
QDEF(MP_QSTR_req_getTlmSensorRawMag, 28262, 22, "req_getTlmSensorRawMag")
QDEF(MP_QSTR_req_getTlmSensorRawRwl, 54884, 22, "req_getTlmSensorRawRwl")
QDEF(MP_QSTR_req_getTlmStrAurigaHealth, 24159, 25, "req_getTlmStrAurigaHealth")
QDEF(MP_QSTR_req_getTlmStrCubeAurigaRaw, 5622, 26, "req_getTlmStrCubeAurigaRaw")
QDEF(MP_QSTR_req_getTlmStrCubeStarRaw, 19211, 24, "req_getTlmStrCubeStarRaw")
QDEF(MP_QSTR_req_getTlmStrHealth, 822, 19, "req_getTlmStrHealth")
QDEF(MP_QSTR_req_getTlmStrPst3sHealth, 60385, 24, "req_getTlmStrPst3sHealth")
QDEF(MP_QSTR_req_getTlmStrPst3sRaw, 18297, 21, "req_getTlmStrPst3sRaw")
QDEF(MP_QSTR_req_getTlmTorquerCurrents, 30847, 25, "req_getTlmTorquerCurrents")
QDEF(MP_QSTR_req_getUnsolicitedEventSetup, 55388, 28, "req_getUnsolicitedEventSetup")
QDEF(MP_QSTR_req_getUnsolicitedTlmSetup, 46629, 26, "req_getUnsolicitedTlmSetup")
QDEF(MP_QSTR_req_get_agent_fdir_level, 45315, 24, "req_get_agent_fdir_level")
QDEF(MP_QSTR_req_get_all_thresh_val, 20703, 22, "req_get_all_thresh_val")
QDEF(MP_QSTR_req_get_commissioning_status, 65011, 28, "req_get_commissioning_status")
QDEF(MP_QSTR_req_get_default_control_mode, 28090, 28, "req_get_default_control_mode")
QDEF(MP_QSTR_req_get_detection_for_fault, 17899, 27, "req_get_detection_for_fault")
QDEF(MP_QSTR_req_get_events_since_last_power_up, 49384, 34, "req_get_events_since_last_power_up")
QDEF(MP_QSTR_req_get_fault, 28031, 13, "req_get_fault")
QDEF(MP_QSTR_req_get_fault_user_clear_level, 10878, 30, "req_get_fault_user_clear_level")
QDEF(MP_QSTR_req_get_fdir_persistent_errors, 32226, 30, "req_get_fdir_persistent_errors")
QDEF(MP_QSTR_req_get_fdir_stats, 46450, 18, "req_get_fdir_stats")
QDEF(MP_QSTR_req_get_force_allow_payloads, 30060, 28, "req_get_force_allow_payloads")
QDEF(MP_QSTR_req_get_min_active_fdir, 14090, 23, "req_get_min_active_fdir")
QDEF(MP_QSTR_req_get_nvm_system_states_cfg, 22748, 29, "req_get_nvm_system_states_cfg")
QDEF(MP_QSTR_req_get_op_mode, 20758, 15, "req_get_op_mode")
QDEF(MP_QSTR_req_get_payload_info, 37770, 20, "req_get_payload_info")
QDEF(MP_QSTR_req_get_system_fdir_level, 16031, 25, "req_get_system_fdir_level")
QDEF(MP_QSTR_req_get_thresh_val, 19393, 18, "req_get_thresh_val")
QDEF(MP_QSTR_req_get_tlm_cfg, 44509, 15, "req_get_tlm_cfg")
QDEF(MP_QSTR_req_reqSoftResetAndMode, 55977, 23, "req_reqSoftResetAndMode")
QDEF(MP_QSTR_req_reqStateMachineStateChange, 20505, 30, "req_reqStateMachineStateChange")
QDEF(MP_QSTR_req_request_mission_mode_enter, 61173, 30, "req_request_mission_mode_enter")
QDEF(MP_QSTR_req_request_mission_mode_exit, 28701, 29, "req_request_mission_mode_exit")
QDEF(MP_QSTR_req_restoreActivePreset, 17341, 23, "req_restoreActivePreset")
QDEF(MP_QSTR_req_sdr_download, 26578, 16, "req_sdr_download")
QDEF(MP_QSTR_req_sdr_get_state, 43352, 17, "req_sdr_get_state")
QDEF(MP_QSTR_req_sdr_poll_latest_ft_status, 8347, 29, "req_sdr_poll_latest_ft_status")
QDEF(MP_QSTR_req_sdr_upload, 41989, 14, "req_sdr_upload")
QDEF(MP_QSTR_req_send_new_event, 6480, 18, "req_send_new_event")
QDEF(MP_QSTR_req_setActivePreset, 2487, 19, "req_setActivePreset")
QDEF(MP_QSTR_req_setAdcsOpState, 57763, 18, "req_setAdcsOpState")
QDEF(MP_QSTR_req_setAdcsRunMode, 11233, 18, "req_setAdcsRunMode")
QDEF(MP_QSTR_req_setConMode, 16319, 14, "req_setConMode")
QDEF(MP_QSTR_req_setConfigActuatorMtq, 42775, 24, "req_setConfigActuatorMtq")
QDEF(MP_QSTR_req_setConfigActuatorRwl, 40438, 24, "req_setConfigActuatorRwl")
QDEF(MP_QSTR_req_setConfigAdcsController, 16573, 27, "req_setConfigAdcsController")
QDEF(MP_QSTR_req_setConfigAdcsEstimator, 9839, 26, "req_setConfigAdcsEstimator")
QDEF(MP_QSTR_req_setConfigAdcsSatellite, 122, 26, "req_setConfigAdcsSatellite")
QDEF(MP_QSTR_req_setConfigAsgp4, 35909, 18, "req_setConfigAsgp4")
QDEF(MP_QSTR_req_setConfigDefaultModes, 36751, 25, "req_setConfigDefaultModes")
QDEF(MP_QSTR_req_setConfigMag0OrbitCal, 643, 25, "req_setConfigMag0OrbitCal")
QDEF(MP_QSTR_req_setConfigMag1OrbitCal, 7106, 25, "req_setConfigMag1OrbitCal")
QDEF(MP_QSTR_req_setConfigMagSensingElement, 37066, 30, "req_setConfigMagSensingElement")
QDEF(MP_QSTR_req_setConfigMount, 13913, 18, "req_setConfigMount")
QDEF(MP_QSTR_req_setConfigNodeSelection, 5172, 26, "req_setConfigNodeSelection")
QDEF(MP_QSTR_req_setConfigOrbitSatParams, 24620, 27, "req_setConfigOrbitSatParams")
QDEF(MP_QSTR_req_setConfigOrbitTargetParams, 58779, 30, "req_setConfigOrbitTargetParams")
QDEF(MP_QSTR_req_setDeployCommandMag, 56025, 23, "req_setDeployCommandMag")
QDEF(MP_QSTR_req_setDummyEvent, 44378, 17, "req_setDummyEvent")
QDEF(MP_QSTR_req_setEraseLogData, 60458, 19, "req_setEraseLogData")
QDEF(MP_QSTR_req_setEstMode, 9663, 14, "req_setEstMode")
QDEF(MP_QSTR_req_setEventLogFilterTransferSetup, 34522, 34, "req_setEventLogFilterTransferSetup")
QDEF(MP_QSTR_req_setFileTransferSetup, 61716, 24, "req_setFileTransferSetup")
QDEF(MP_QSTR_req_setGnssSensorCmd, 35275, 20, "req_setGnssSensorCmd")
QDEF(MP_QSTR_req_setImageFileInfoReset, 54084, 25, "req_setImageFileInfoReset")
QDEF(MP_QSTR_req_setImageTransferSetup, 65365, 25, "req_setImageTransferSetup")
QDEF(MP_QSTR_req_setOpenLoopCommandHxyzRW, 12007, 28, "req_setOpenLoopCommandHxyzRW")
QDEF(MP_QSTR_req_setOpenLoopCommandMtq, 24409, 25, "req_setOpenLoopCommandMtq")
QDEF(MP_QSTR_req_setOpenLoopCommandRwl, 440, 25, "req_setOpenLoopCommandRwl")
QDEF(MP_QSTR_req_setOrbMode, 31554, 14, "req_setOrbMode")
QDEF(MP_QSTR_req_setPassThrough, 61556, 18, "req_setPassThrough")
QDEF(MP_QSTR_req_setPortMap, 16763, 14, "req_setPortMap")
QDEF(MP_QSTR_req_setPowerState, 39670, 17, "req_setPowerState")
QDEF(MP_QSTR_req_setReferenceFmcParam, 48818, 24, "req_setReferenceFmcParam")
QDEF(MP_QSTR_req_setReferenceIrcVector, 46932, 25, "req_setReferenceIrcVector")
QDEF(MP_QSTR_req_setReferenceRpy, 10670, 19, "req_setReferenceRpy")
QDEF(MP_QSTR_req_setReferenceTarget, 46340, 22, "req_setReferenceTarget")
QDEF(MP_QSTR_req_setSimSensorRaw, 7899, 19, "req_setSimSensorRaw")
QDEF(MP_QSTR_req_setTelemetryFileSzLimitConfig, 21217, 33, "req_setTelemetryFileSzLimitConfig")
QDEF(MP_QSTR_req_setTelemetryGeneralConfig, 4877, 29, "req_setTelemetryGeneralConfig")
QDEF(MP_QSTR_req_setTelemetryLogTransferSetup, 43449, 32, "req_setTelemetryLogTransferSetup")
QDEF(MP_QSTR_req_setTelemetryPresetConfig, 55230, 28, "req_setTelemetryPresetConfig")
QDEF(MP_QSTR_req_setUnsolicitedEventSetup, 12488, 28, "req_setUnsolicitedEventSetup")
QDEF(MP_QSTR_req_setUnsolicitedTlmSetup, 47793, 26, "req_setUnsolicitedTlmSetup")
QDEF(MP_QSTR_req_set_all_thresh_val, 41803, 22, "req_set_all_thresh_val")
QDEF(MP_QSTR_req_set_commissioning_status, 23143, 28, "req_set_commissioning_status")
QDEF(MP_QSTR_req_set_default_control_mode, 6190, 28, "req_set_default_control_mode")
QDEF(MP_QSTR_req_set_detection_for_all_faults, 37554, 32, "req_set_detection_for_all_faults")
QDEF(MP_QSTR_req_set_detection_for_fault, 4351, 27, "req_set_detection_for_fault")
QDEF(MP_QSTR_req_set_fault, 51819, 13, "req_set_fault")
QDEF(MP_QSTR_req_set_fault_user_clear_level, 45034, 30, "req_set_fault_user_clear_level")
QDEF(MP_QSTR_req_set_force_allow_payloads, 13304, 28, "req_set_force_allow_payloads")
QDEF(MP_QSTR_req_set_min_active_fdir, 32030, 23, "req_set_min_active_fdir")
QDEF(MP_QSTR_req_set_nvm_system_states_cfg, 52168, 29, "req_set_nvm_system_states_cfg")
QDEF(MP_QSTR_req_set_thresh_val, 3413, 18, "req_set_thresh_val")
QDEF(MP_QSTR_req_set_tlm_cfg, 6601, 15, "req_set_tlm_cfg")
QDEF(MP_QSTR_req_startTelemetry, 9043, 18, "req_startTelemetry")
QDEF(MP_QSTR_req_start_payload, 8877, 17, "req_start_payload")
QDEF(MP_QSTR_req_stopTelemetry, 55595, 17, "req_stopTelemetry")
QDEF(MP_QSTR_req_stop_payload, 54485, 16, "req_stop_payload")
QDEF(MP_QSTR_resp_cleanTelemetryFiles, 10833, 24, "resp_cleanTelemetryFiles")
QDEF(MP_QSTR_resp_clear_events_since_last_power_up, 31125, 37, "resp_clear_events_since_last_power_up")
QDEF(MP_QSTR_resp_clear_fdir_persistent_errors, 29151, 33, "resp_clear_fdir_persistent_errors")
QDEF(MP_QSTR_resp_clear_fdir_stats, 41807, 21, "resp_clear_fdir_stats")
QDEF(MP_QSTR_resp_download_evt, 5314, 17, "resp_download_evt")
QDEF(MP_QSTR_resp_download_evt_status, 2217, 24, "resp_download_evt_status")
QDEF(MP_QSTR_resp_download_img_direct, 12180, 24, "resp_download_img_direct")
QDEF(MP_QSTR_resp_download_img_direct_status, 4671, 31, "resp_download_img_direct_status")
QDEF(MP_QSTR_resp_download_tlm, 21264, 17, "resp_download_tlm")
QDEF(MP_QSTR_resp_download_tlm_status, 13627, 24, "resp_download_tlm_status")
QDEF(MP_QSTR_resp_force_clear_all_faults, 29197, 27, "resp_force_clear_all_faults")
QDEF(MP_QSTR_resp_force_clear_fault, 17504, 22, "resp_force_clear_fault")
QDEF(MP_QSTR_resp_fw_update_cube_computer, 58471, 28, "resp_fw_update_cube_computer")
QDEF(MP_QSTR_resp_fw_update_cube_computer_status, 17196, 35, "resp_fw_update_cube_computer_status")
QDEF(MP_QSTR_resp_fw_update_cube_node, 37920, 24, "resp_fw_update_cube_node")
QDEF(MP_QSTR_resp_fw_update_cube_node_status, 40011, 31, "resp_fw_update_cube_node_status")
QDEF(MP_QSTR_resp_getActivePreset, 5425, 20, "resp_getActivePreset")
QDEF(MP_QSTR_resp_getAdcsOpState, 34789, 19, "resp_getAdcsOpState")
QDEF(MP_QSTR_resp_getAdcsRunMode, 25127, 19, "resp_getAdcsRunMode")
QDEF(MP_QSTR_resp_getComponentErrorCodes, 23569, 27, "resp_getComponentErrorCodes")
QDEF(MP_QSTR_resp_getConMode, 21753, 15, "resp_getConMode")
QDEF(MP_QSTR_resp_getConfigActuatorMtq, 20817, 25, "resp_getConfigActuatorMtq")
QDEF(MP_QSTR_resp_getConfigActuatorRwl, 14256, 25, "resp_getConfigActuatorRwl")
QDEF(MP_QSTR_resp_getConfigAdcsController, 56763, 28, "resp_getConfigAdcsController")
QDEF(MP_QSTR_resp_getConfigAdcsEstimator, 27433, 27, "resp_getConfigAdcsEstimator")
QDEF(MP_QSTR_resp_getConfigAdcsSatellite, 54332, 27, "resp_getConfigAdcsSatellite")
QDEF(MP_QSTR_resp_getConfigAsgp4, 12931, 19, "resp_getConfigAsgp4")
QDEF(MP_QSTR_resp_getConfigDefaultModes, 25993, 26, "resp_getConfigDefaultModes")
QDEF(MP_QSTR_resp_getConfigMag0OrbitCal, 22533, 26, "resp_getConfigMag0OrbitCal")
QDEF(MP_QSTR_resp_getConfigMag1OrbitCal, 20548, 26, "resp_getConfigMag1OrbitCal")
QDEF(MP_QSTR_resp_getConfigMagSensingElement, 2060, 31, "resp_getConfigMagSensingElement")
QDEF(MP_QSTR_resp_getConfigMount, 11167, 19, "resp_getConfigMount")
QDEF(MP_QSTR_resp_getConfigNodeSelection, 10098, 27, "resp_getConfigNodeSelection")
QDEF(MP_QSTR_resp_getConfigOrbitSatParams, 60842, 28, "resp_getConfigOrbitSatParams")
QDEF(MP_QSTR_resp_getConfigOrbitTargetParams, 27229, 31, "resp_getConfigOrbitTargetParams")
QDEF(MP_QSTR_resp_getCubeNodePortMap, 3692, 23, "resp_getCubeNodePortMap")
QDEF(MP_QSTR_resp_getEstMode, 52217, 15, "resp_getEstMode")
QDEF(MP_QSTR_resp_getEventLogStatus, 60580, 22, "resp_getEventLogStatus")
QDEF(MP_QSTR_resp_getExpectedNodes, 32405, 21, "resp_getExpectedNodes")
QDEF(MP_QSTR_resp_getFileInfo, 16112, 16, "resp_getFileInfo")
QDEF(MP_QSTR_resp_getFileTransferSetup, 41170, 25, "resp_getFileTransferSetup")
QDEF(MP_QSTR_resp_getFileTransferStatus, 60769, 26, "resp_getFileTransferStatus")
QDEF(MP_QSTR_resp_getImageFileInfo, 60535, 21, "resp_getImageFileInfo")
QDEF(MP_QSTR_resp_getImageTransferStatus, 37824, 27, "resp_getImageTransferStatus")
QDEF(MP_QSTR_resp_getOpStatus, 38931, 16, "resp_getOpStatus")
QDEF(MP_QSTR_resp_getOpenLoopCommandHxyzRW, 24865, 29, "resp_getOpenLoopCommandHxyzRW")
QDEF(MP_QSTR_resp_getOpenLoopCommandMtq, 59103, 26, "resp_getOpenLoopCommandMtq")
QDEF(MP_QSTR_resp_getOpenLoopCommandRwl, 30654, 26, "resp_getOpenLoopCommandRwl")
QDEF(MP_QSTR_resp_getOrbMode, 12164, 15, "resp_getOrbMode")
QDEF(MP_QSTR_resp_getPassThrough, 54194, 19, "resp_getPassThrough")
QDEF(MP_QSTR_resp_getPortDiagnostics, 30165, 23, "resp_getPortDiagnostics")
QDEF(MP_QSTR_resp_getPortMap, 46781, 15, "resp_getPortMap")
QDEF(MP_QSTR_resp_getPowerState, 61424, 18, "resp_getPowerState")
QDEF(MP_QSTR_resp_getReferenceFmcParam, 18676, 25, "resp_getReferenceFmcParam")
QDEF(MP_QSTR_resp_getReferenceIrcVector, 47186, 26, "resp_getReferenceIrcVector")
QDEF(MP_QSTR_resp_getReferenceRpy, 21672, 20, "resp_getReferenceRpy")
QDEF(MP_QSTR_resp_getReferenceTarget, 48322, 23, "resp_getReferenceTarget")
QDEF(MP_QSTR_resp_getSimSensorRaw, 23645, 20, "resp_getSimSensorRaw")
QDEF(MP_QSTR_resp_getStateMachineState, 28829, 25, "resp_getStateMachineState")
QDEF(MP_QSTR_resp_getTelemetryFileSinkConfig, 29284, 31, "resp_getTelemetryFileSinkConfig")
QDEF(MP_QSTR_resp_getTelemetryGeneralConfig, 34571, 30, "resp_getTelemetryGeneralConfig")
QDEF(MP_QSTR_resp_getTelemetryOperationStats, 58723, 31, "resp_getTelemetryOperationStats")
QDEF(MP_QSTR_resp_getTelemetryPresetConfig, 26360, 29, "resp_getTelemetryPresetConfig")
QDEF(MP_QSTR_resp_getTelemtryLogInclusionMasks, 41143, 33, "resp_getTelemtryLogInclusionMasks")
QDEF(MP_QSTR_resp_getTelemtryLogStatus, 42978, 25, "resp_getTelemtryLogStatus")
QDEF(MP_QSTR_resp_getTlmAcpExecution, 58093, 23, "resp_getTlmAcpExecution")
QDEF(MP_QSTR_resp_getTlmAsgp4, 13980, 16, "resp_getTlmAsgp4")
QDEF(MP_QSTR_resp_getTlmController, 9201, 21, "resp_getTlmController")
QDEF(MP_QSTR_resp_getTlmCubeComputerHealth, 24167, 29, "resp_getTlmCubeComputerHealth")
QDEF(MP_QSTR_resp_getTlmCubeMagHealth, 59819, 24, "resp_getTlmCubeMagHealth")
QDEF(MP_QSTR_resp_getTlmEstimatorBackup, 65037, 26, "resp_getTlmEstimatorBackup")
QDEF(MP_QSTR_resp_getTlmEstimatorMain, 13704, 24, "resp_getTlmEstimatorMain")
QDEF(MP_QSTR_resp_getTlmEstimatorMainHighRes, 60130, 31, "resp_getTlmEstimatorMainHighRes")
QDEF(MP_QSTR_resp_getTlmExecutionPoint, 12659, 25, "resp_getTlmExecutionPoint")
QDEF(MP_QSTR_resp_getTlmExtSensorRaw, 18870, 23, "resp_getTlmExtSensorRaw")
QDEF(MP_QSTR_resp_getTlmFssCubeSenseSunHealth, 416, 32, "resp_getTlmFssCubeSenseSunHealth")
QDEF(MP_QSTR_resp_getTlmFssCubeSenseSunRaw, 52952, 29, "resp_getTlmFssCubeSenseSunRaw")
QDEF(MP_QSTR_resp_getTlmGnssRaw, 6208, 18, "resp_getTlmGnssRaw")
QDEF(MP_QSTR_resp_getTlmGnssUartStatus, 32802, 25, "resp_getTlmGnssUartStatus")
QDEF(MP_QSTR_resp_getTlmGyrLitefuforsRaw, 18570, 27, "resp_getTlmGyrLitefuforsRaw")
QDEF(MP_QSTR_resp_getTlmHil, 65344, 14, "resp_getTlmHil")
QDEF(MP_QSTR_resp_getTlmHssCubeSenseEarthHealth, 5164, 34, "resp_getTlmHssCubeSenseEarthHealth")
QDEF(MP_QSTR_resp_getTlmHssCubeSenseEarthRaw, 19668, 31, "resp_getTlmHssCubeSenseEarthRaw")
QDEF(MP_QSTR_resp_getTlmLitefuforsHealth, 63614, 27, "resp_getTlmLitefuforsHealth")
QDEF(MP_QSTR_resp_getTlmModels, 54097, 17, "resp_getTlmModels")
QDEF(MP_QSTR_resp_getTlmNodeInitState, 32544, 24, "resp_getTlmNodeInitState")
QDEF(MP_QSTR_resp_getTlmNssRwlHealth, 16086, 23, "resp_getTlmNssRwlHealth")
QDEF(MP_QSTR_resp_getTlmRwlHealth, 23768, 20, "resp_getTlmRwlHealth")
QDEF(MP_QSTR_resp_getTlmRwlNssRwlRaw, 44487, 23, "resp_getTlmRwlNssRwlRaw")
QDEF(MP_QSTR_resp_getTlmSensorCalCss, 53750, 23, "resp_getTlmSensorCalCss")
QDEF(MP_QSTR_resp_getTlmSensorCalFss, 48179, 23, "resp_getTlmSensorCalFss")
QDEF(MP_QSTR_resp_getTlmSensorCalGnss, 13596, 24, "resp_getTlmSensorCalGnss")
QDEF(MP_QSTR_resp_getTlmSensorCalGyro, 63670, 24, "resp_getTlmSensorCalGyro")
QDEF(MP_QSTR_resp_getTlmSensorCalHss, 54973, 23, "resp_getTlmSensorCalHss")
QDEF(MP_QSTR_resp_getTlmSensorCalMag, 52158, 23, "resp_getTlmSensorCalMag")
QDEF(MP_QSTR_resp_getTlmSensorCalRwl, 36028, 23, "resp_getTlmSensorCalRwl")
QDEF(MP_QSTR_resp_getTlmSensorCalStr, 37184, 23, "resp_getTlmSensorCalStr")
QDEF(MP_QSTR_resp_getTlmSensorRawCss, 39932, 23, "resp_getTlmSensorRawCss")
QDEF(MP_QSTR_resp_getTlmSensorRawGyro, 45052, 24, "resp_getTlmSensorRawGyro")
QDEF(MP_QSTR_resp_getTlmSensorRawMag, 33588, 23, "resp_getTlmSensorRawMag")
QDEF(MP_QSTR_resp_getTlmSensorRawRwl, 22198, 23, "resp_getTlmSensorRawRwl")
QDEF(MP_QSTR_resp_getTlmStrAurigaHealth, 18765, 26, "resp_getTlmStrAurigaHealth")
QDEF(MP_QSTR_resp_getTlmStrCubeAurigaRaw, 44324, 27, "resp_getTlmStrCubeAurigaRaw")
QDEF(MP_QSTR_resp_getTlmStrCubeStarRaw, 3033, 25, "resp_getTlmStrCubeStarRaw")
QDEF(MP_QSTR_resp_getTlmStrHealth, 32804, 20, "resp_getTlmStrHealth")
QDEF(MP_QSTR_resp_getTlmStrPst3sHealth, 60211, 25, "resp_getTlmStrPst3sHealth")
QDEF(MP_QSTR_resp_getTlmStrPst3sRaw, 55019, 22, "resp_getTlmStrPst3sRaw")
QDEF(MP_QSTR_resp_getTlmTorquerCurrents, 29933, 26, "resp_getTlmTorquerCurrents")
QDEF(MP_QSTR_resp_getUnsolicitedEventSetup, 52110, 29, "resp_getUnsolicitedEventSetup")
QDEF(MP_QSTR_resp_getUnsolicitedTlmSetup, 3447, 27, "resp_getUnsolicitedTlmSetup")
QDEF(MP_QSTR_resp_get_agent_fdir_level, 24145, 25, "resp_get_agent_fdir_level")
QDEF(MP_QSTR_resp_get_all_thresh_val, 10125, 23, "resp_get_all_thresh_val")
QDEF(MP_QSTR_resp_get_commissioning_status, 1697, 29, "resp_get_commissioning_status")
QDEF(MP_QSTR_resp_get_default_control_mode, 50408, 29, "resp_get_default_control_mode")
QDEF(MP_QSTR_resp_get_detection_for_fault, 28537, 28, "resp_get_detection_for_fault")
QDEF(MP_QSTR_resp_get_events_since_last_power_up, 48058, 35, "resp_get_events_since_last_power_up")
QDEF(MP_QSTR_resp_get_fault, 15853, 14, "resp_get_fault")
QDEF(MP_QSTR_resp_get_fault_user_clear_level, 1068, 31, "resp_get_fault_user_clear_level")
QDEF(MP_QSTR_resp_get_fdir_persistent_errors, 8752, 31, "resp_get_fdir_persistent_errors")
QDEF(MP_QSTR_resp_get_fdir_stats, 3744, 19, "resp_get_fdir_stats")
QDEF(MP_QSTR_resp_get_force_allow_payloads, 25278, 29, "resp_get_force_allow_payloads")
QDEF(MP_QSTR_resp_get_min_active_fdir, 43288, 24, "resp_get_min_active_fdir")
QDEF(MP_QSTR_resp_get_nvm_system_states_cfg, 28366, 30, "resp_get_nvm_system_states_cfg")
QDEF(MP_QSTR_resp_get_op_mode, 29060, 16, "resp_get_op_mode")
QDEF(MP_QSTR_resp_get_payload_info, 57048, 21, "resp_get_payload_info")
QDEF(MP_QSTR_resp_get_system_fdir_level, 42253, 26, "resp_get_system_fdir_level")
QDEF(MP_QSTR_resp_get_thresh_val, 62099, 19, "resp_get_thresh_val")
QDEF(MP_QSTR_resp_get_tlm_cfg, 14415, 16, "resp_get_tlm_cfg")
QDEF(MP_QSTR_resp_reqSoftResetAndMode, 59707, 24, "resp_reqSoftResetAndMode")
QDEF(MP_QSTR_resp_reqStateMachineStateChange, 27595, 31, "resp_reqStateMachineStateChange")
QDEF(MP_QSTR_resp_request_mission_mode_enter, 42279, 31, "resp_request_mission_mode_enter")
QDEF(MP_QSTR_resp_request_mission_mode_exit, 63759, 30, "resp_request_mission_mode_exit")
QDEF(MP_QSTR_resp_restoreActivePreset, 49583, 24, "resp_restoreActivePreset")
QDEF(MP_QSTR_resp_sdr_download, 25088, 17, "resp_sdr_download")
QDEF(MP_QSTR_resp_sdr_get_state, 42826, 18, "resp_sdr_get_state")
QDEF(MP_QSTR_resp_sdr_poll_latest_ft_status, 47113, 30, "resp_sdr_poll_latest_ft_status")
QDEF(MP_QSTR_resp_sdr_upload, 62423, 15, "resp_sdr_upload")
QDEF(MP_QSTR_resp_send_new_event, 29698, 19, "resp_send_new_event")
QDEF(MP_QSTR_resp_setActivePreset, 42277, 20, "resp_setActivePreset")
QDEF(MP_QSTR_resp_setAdcsOpState, 1649, 19, "resp_setAdcsOpState")
QDEF(MP_QSTR_resp_setAdcsRunMode, 10163, 19, "resp_setAdcsRunMode")
QDEF(MP_QSTR_resp_setConMode, 27501, 15, "resp_setConMode")
QDEF(MP_QSTR_resp_setConfigActuatorMtq, 30149, 25, "resp_setConfigActuatorMtq")
QDEF(MP_QSTR_resp_setConfigActuatorRwl, 64548, 25, "resp_setConfigActuatorRwl")
QDEF(MP_QSTR_resp_setConfigAdcsController, 52655, 28, "resp_setConfigAdcsController")
QDEF(MP_QSTR_resp_setConfigAdcsEstimator, 41405, 27, "resp_setConfigAdcsEstimator")
QDEF(MP_QSTR_resp_setConfigAdcsSatellite, 51368, 27, "resp_setConfigAdcsSatellite")
QDEF(MP_QSTR_resp_setConfigAsgp4, 43287, 19, "resp_setConfigAsgp4")
QDEF(MP_QSTR_resp_setConfigDefaultModes, 11677, 26, "resp_setConfigDefaultModes")
QDEF(MP_QSTR_resp_setConfigMag0OrbitCal, 19473, 26, "resp_setConfigMag0OrbitCal")
QDEF(MP_QSTR_resp_setConfigMag1OrbitCal, 17488, 26, "resp_setConfigMag1OrbitCal")
QDEF(MP_QSTR_resp_setConfigMagSensingElement, 60312, 31, "resp_setConfigMagSensingElement")
QDEF(MP_QSTR_resp_setConfigMount, 16907, 19, "resp_setConfigMount")
QDEF(MP_QSTR_resp_setConfigNodeSelection, 55782, 27, "resp_setConfigNodeSelection")
QDEF(MP_QSTR_resp_setConfigOrbitSatParams, 46014, 28, "resp_setConfigOrbitSatParams")
QDEF(MP_QSTR_resp_setConfigOrbitTargetParams, 969, 31, "resp_setConfigOrbitTargetParams")
QDEF(MP_QSTR_resp_setDeployCommandMag, 38347, 24, "resp_setDeployCommandMag")
QDEF(MP_QSTR_resp_setDummyEvent, 59208, 18, "resp_setDummyEvent")
QDEF(MP_QSTR_resp_setEraseLogData, 32440, 20, "resp_setEraseLogData")
QDEF(MP_QSTR_resp_setEstMode, 17773, 15, "resp_setEstMode")
QDEF(MP_QSTR_resp_setEventLogFilterTransferSetup, 39688, 35, "resp_setEventLogFilterTransferSetup")
QDEF(MP_QSTR_resp_setFileTransferSetup, 20038, 25, "resp_setFileTransferSetup")
QDEF(MP_QSTR_resp_setGnssSensorCmd, 11289, 21, "resp_setGnssSensorCmd")
QDEF(MP_QSTR_resp_setImageFileInfoReset, 16982, 26, "resp_setImageFileInfoReset")
QDEF(MP_QSTR_resp_setImageTransferSetup, 29511, 26, "resp_setImageTransferSetup")
QDEF(MP_QSTR_resp_setOpenLoopCommandHxyzRW, 59573, 29, "resp_setOpenLoopCommandHxyzRW")
QDEF(MP_QSTR_resp_setOpenLoopCommandMtq, 58059, 26, "resp_setOpenLoopCommandMtq")
QDEF(MP_QSTR_resp_setOpenLoopCommandRwl, 54186, 26, "resp_setOpenLoopCommandRwl")
QDEF(MP_QSTR_resp_setOrbMode, 30992, 15, "resp_setOrbMode")
QDEF(MP_QSTR_resp_setPassThrough, 46886, 19, "resp_setPassThrough")
QDEF(MP_QSTR_resp_setPortMap, 41001, 15, "resp_setPortMap")
QDEF(MP_QSTR_resp_setPowerState, 29668, 18, "resp_setPowerState")
QDEF(MP_QSTR_resp_setReferenceFmcParam, 38240, 25, "resp_setReferenceFmcParam")
QDEF(MP_QSTR_resp_setReferenceIrcVector, 23110, 26, "resp_setReferenceIrcVector")
QDEF(MP_QSTR_resp_setReferenceRpy, 9660, 20, "resp_setReferenceRpy")
QDEF(MP_QSTR_resp_setReferenceTarget, 47446, 23, "resp_setReferenceTarget")
QDEF(MP_QSTR_resp_setSimSensorRaw, 54857, 20, "resp_setSimSensorRaw")
QDEF(MP_QSTR_resp_setTelemetryFileSzLimitConfig, 7027, 34, "resp_setTelemetryFileSzLimitConfig")
QDEF(MP_QSTR_resp_setTelemetryGeneralConfig, 39199, 30, "resp_setTelemetryGeneralConfig")
QDEF(MP_QSTR_resp_setTelemetryLogTransferSetup, 57835, 33, "resp_setTelemetryLogTransferSetup")
QDEF(MP_QSTR_resp_setTelemetryPresetConfig, 22380, 29, "resp_setTelemetryPresetConfig")
QDEF(MP_QSTR_resp_setUnsolicitedEventSetup, 38938, 29, "resp_setUnsolicitedEventSetup")
QDEF(MP_QSTR_resp_setUnsolicitedTlmSetup, 3555, 27, "resp_setUnsolicitedTlmSetup")
QDEF(MP_QSTR_resp_set_all_thresh_val, 38425, 23, "resp_set_all_thresh_val")
QDEF(MP_QSTR_resp_set_commissioning_status, 3893, 29, "resp_set_commissioning_status")
QDEF(MP_QSTR_resp_set_default_control_mode, 64380, 29, "resp_set_default_control_mode")
QDEF(MP_QSTR_resp_set_detection_for_all_faults, 46688, 33, "resp_set_detection_for_all_faults")
QDEF(MP_QSTR_resp_set_detection_for_fault, 49773, 28, "resp_set_detection_for_fault")
QDEF(MP_QSTR_resp_set_fault, 41721, 14, "resp_set_fault")
QDEF(MP_QSTR_resp_set_fault_user_clear_level, 32184, 31, "resp_set_fault_user_clear_level")
QDEF(MP_QSTR_resp_set_force_allow_payloads, 50474, 29, "resp_set_force_allow_payloads")
QDEF(MP_QSTR_resp_set_min_active_fdir, 34572, 24, "resp_set_min_active_fdir")
QDEF(MP_QSTR_resp_set_nvm_system_states_cfg, 63962, 30, "resp_set_nvm_system_states_cfg")
QDEF(MP_QSTR_resp_set_thresh_val, 45063, 19, "resp_set_thresh_val")
QDEF(MP_QSTR_resp_set_tlm_cfg, 11355, 16, "resp_set_tlm_cfg")
QDEF(MP_QSTR_resp_startTelemetry, 8705, 19, "resp_startTelemetry")
QDEF(MP_QSTR_resp_start_payload, 43455, 18, "resp_start_payload")
QDEF(MP_QSTR_resp_stopTelemetry, 42681, 18, "resp_stopTelemetry")
QDEF(MP_QSTR_resp_stop_payload, 27143, 17, "resp_stop_payload")
QDEF(MP_QSTR_return_status, 22596, 13, "return_status")
QDEF(MP_QSTR_reversed, 28321, 8, "reversed")
QDEF(MP_QSTR_rmdir, 42821, 5, "rmdir")
QDEF(MP_QSTR_seek, 30109, 4, "seek")
QDEF(MP_QSTR_setter, 22788, 6, "setter")
QDEF(MP_QSTR_sin, 37041, 3, "sin")
QDEF(MP_QSTR_sleep, 10218, 5, "sleep")
QDEF(MP_QSTR_sleep_ms, 25355, 8, "sleep_ms")
QDEF(MP_QSTR_sleep_us, 24595, 8, "sleep_us")
QDEF(MP_QSTR_slice, 62645, 5, "slice")
QDEF(MP_QSTR_sqrt, 17441, 4, "sqrt")
QDEF(MP_QSTR_stat, 13783, 4, "stat")
QDEF(MP_QSTR_state_change_args, 1619, 17, "state_change_args")
QDEF(MP_QSTR_state_change_args_make_from_buf, 8617, 31, "state_change_args_make_from_buf")
QDEF(MP_QSTR_state_change_core_args, 54615, 22, "state_change_core_args")
QDEF(MP_QSTR_state_change_core_args_make_from_buf, 41389, 36, "state_change_core_args_make_from_buf")
QDEF(MP_QSTR_statvfs, 6420, 7, "statvfs")
QDEF(MP_QSTR_struct, 36882, 6, "struct")
QDEF(MP_QSTR_symmetric_difference, 26574, 20, "symmetric_difference")
QDEF(MP_QSTR_symmetric_difference_update, 63584, 27, "symmetric_difference_update")
QDEF(MP_QSTR_sync, 25250, 4, "sync")
QDEF(MP_QSTR_sys, 36540, 3, "sys")
QDEF(MP_QSTR_sys_states, 62023, 10, "sys_states")
QDEF(MP_QSTR_tan, 25086, 3, "tan")
QDEF(MP_QSTR_telemetry_mask_0, 46, 16, "telemetry_mask_0")
QDEF(MP_QSTR_telemetry_mask_0_make_from_buf, 10068, 30, "telemetry_mask_0_make_from_buf")
QDEF(MP_QSTR_telemetry_mask_1, 47, 16, "telemetry_mask_1")
QDEF(MP_QSTR_telemetry_mask_1_make_from_buf, 50389, 30, "telemetry_mask_1_make_from_buf")
QDEF(MP_QSTR_telemetry_mask_2, 44, 16, "telemetry_mask_2")
QDEF(MP_QSTR_telemetry_mask_2_make_from_buf, 12118, 30, "telemetry_mask_2_make_from_buf")
QDEF(MP_QSTR_telemetry_mask_3, 45, 16, "telemetry_mask_3")
QDEF(MP_QSTR_telemetry_mask_3_make_from_buf, 27607, 30, "telemetry_mask_3_make_from_buf")
QDEF(MP_QSTR_telemetry_mask_4, 42, 16, "telemetry_mask_4")
QDEF(MP_QSTR_telemetry_mask_4_make_from_buf, 46672, 30, "telemetry_mask_4_make_from_buf")
QDEF(MP_QSTR_tell, 45332, 4, "tell")
QDEF(MP_QSTR_threshold, 12274, 9, "threshold")
QDEF(MP_QSTR_ticks_add, 44701, 9, "ticks_add")
QDEF(MP_QSTR_ticks_cpu, 42266, 9, "ticks_cpu")
QDEF(MP_QSTR_ticks_diff, 57521, 10, "ticks_diff")
QDEF(MP_QSTR_ticks_ms, 12866, 8, "ticks_ms")
QDEF(MP_QSTR_ticks_us, 12634, 8, "ticks_us")
QDEF(MP_QSTR_time, 49648, 4, "time")
QDEF(MP_QSTR_time_ns, 45682, 7, "time_ns")
QDEF(MP_QSTR_tlm_file_logging_type, 45170, 21, "tlm_file_logging_type")
QDEF(MP_QSTR_tlm_file_size_limit_cfg, 43012, 23, "tlm_file_size_limit_cfg")
QDEF(MP_QSTR_tlm_file_size_limit_cfg_make_from_buf, 43006, 37, "tlm_file_size_limit_cfg_make_from_buf")
QDEF(MP_QSTR_tlm_general_cfg, 8740, 15, "tlm_general_cfg")
QDEF(MP_QSTR_tlm_general_cfg_make_from_buf, 29022, 29, "tlm_general_cfg_make_from_buf")
QDEF(MP_QSTR_tlm_preset_cfg, 49367, 14, "tlm_preset_cfg")
QDEF(MP_QSTR_tlm_preset_cfg_make_from_buf, 44333, 28, "tlm_preset_cfg_make_from_buf")
QDEF(MP_QSTR_tlm_stats, 31630, 9, "tlm_stats")
QDEF(MP_QSTR_tlm_stats_make_from_buf, 53876, 23, "tlm_stats_make_from_buf")
QDEF(MP_QSTR_trunc, 39259, 5, "trunc")
QDEF(MP_QSTR_umount, 40669, 6, "umount")
QDEF(MP_QSTR_union, 31990, 5, "union")
QDEF(MP_QSTR_unpack, 15367, 6, "unpack")
QDEF(MP_QSTR_unpack_from, 27918, 11, "unpack_from")
QDEF(MP_QSTR_upy_conops, 48520, 10, "upy_conops")
QDEF(MP_QSTR_upy_cubeadcs_gen2_cubecomputercommon3, 39700, 37, "upy_cubeadcs_gen2_cubecomputercommon3")
QDEF(MP_QSTR_upy_cubeadcs_gen2_cubecomputercontrolprogram8, 47425, 45, "upy_cubeadcs_gen2_cubecomputercontrolprogram8")
QDEF(MP_QSTR_upy_fdir_srv, 52055, 12, "upy_fdir_srv")
QDEF(MP_QSTR_upy_obc_cubeadcs_gen2, 56498, 21, "upy_obc_cubeadcs_gen2")
QDEF(MP_QSTR_upy_payload_ctrl, 21502, 16, "upy_payload_ctrl")
QDEF(MP_QSTR_upy_sdr, 53123, 7, "upy_sdr")
QDEF(MP_QSTR_upy_telemetry, 11753, 13, "upy_telemetry")
QDEF(MP_QSTR_usys, 62409, 4, "usys")
QDEF(MP_QSTR_version, 54207, 7, "version")
QDEF(MP_QSTR_version_info, 2670, 12, "version_info")
QDEF(MP_QSTR_writeblocks, 57090, 11, "writeblocks")
