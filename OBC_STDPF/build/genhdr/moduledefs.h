// Automatically generated by makemoduledefs.py.

extern const struct _mp_obj_module_t mp_module_array;
#undef MODULE_DEF_ARRAY
#define MODULE_DEF_ARRAY { MP_ROM_QSTR(MP_QSTR_array), MP_ROM_PTR(&mp_module_array) },

extern const struct _mp_obj_module_t mp_module_collections;
#undef MODULE_DEF_COLLECTIONS
#define MODULE_DEF_COLLECTIONS { MP_ROM_QSTR(MP_QSTR_collections), MP_ROM_PTR(&mp_module_collections) },

extern const struct _mp_obj_module_t mp_module_io;
#undef MODULE_DEF_IO
#define MODULE_DEF_IO { MP_ROM_QSTR(MP_QSTR_io), MP_ROM_PTR(&mp_module_io) },

extern const struct _mp_obj_module_t mp_module_struct;
#undef MODULE_DEF_STRUCT
#define MODULE_DEF_STRUCT { MP_ROM_QSTR(MP_QSTR_struct), MP_ROM_PTR(&mp_module_struct) },

extern const struct _mp_obj_module_t mp_module_time;
#undef MODULE_DEF_TIME
#define MODULE_DEF_TIME { MP_ROM_QSTR(MP_QSTR_time), MP_ROM_PTR(&mp_module_time) },

extern const struct _mp_obj_module_t mp_module___main__;
#undef MODULE_DEF___MAIN__
#define MODULE_DEF___MAIN__ { MP_ROM_QSTR(MP_QSTR___main__), MP_ROM_PTR(&mp_module___main__) },

extern const struct _mp_obj_module_t mp_module_builtins;
#undef MODULE_DEF_BUILTINS
#define MODULE_DEF_BUILTINS { MP_ROM_QSTR(MP_QSTR_builtins), MP_ROM_PTR(&mp_module_builtins) },

extern const struct _mp_obj_module_t fmng_user_cmodule;
#undef MODULE_DEF_FMNG
#define MODULE_DEF_FMNG { MP_ROM_QSTR(MP_QSTR_fmng), MP_ROM_PTR(&fmng_user_cmodule) },

extern const struct _mp_obj_module_t mp_module_gc;
#undef MODULE_DEF_GC
#define MODULE_DEF_GC { MP_ROM_QSTR(MP_QSTR_gc), MP_ROM_PTR(&mp_module_gc) },

extern const struct _mp_obj_module_t mp_module_math;
#undef MODULE_DEF_MATH
#define MODULE_DEF_MATH { MP_ROM_QSTR(MP_QSTR_math), MP_ROM_PTR(&mp_module_math) },

extern const struct _mp_obj_module_t mp_module_micropython;
#undef MODULE_DEF_MICROPYTHON
#define MODULE_DEF_MICROPYTHON { MP_ROM_QSTR(MP_QSTR_micropython), MP_ROM_PTR(&mp_module_micropython) },

extern const struct _mp_obj_module_t obc_comm_gw_user_cmodule;
#undef MODULE_DEF_OBC_COMM_GW
#define MODULE_DEF_OBC_COMM_GW { MP_ROM_QSTR(MP_QSTR_obc_comm_gw), MP_ROM_PTR(&obc_comm_gw_user_cmodule) },

extern const struct _mp_obj_module_t mp_module_sys;
#undef MODULE_DEF_SYS
#define MODULE_DEF_SYS { MP_ROM_QSTR(MP_QSTR_sys), MP_ROM_PTR(&mp_module_sys) },

extern const struct _mp_obj_module_t upy_conops_user_cmodule;
#undef MODULE_DEF_UPY_CONOPS
#define MODULE_DEF_UPY_CONOPS { MP_ROM_QSTR(MP_QSTR_upy_conops), MP_ROM_PTR(&upy_conops_user_cmodule) },

extern const struct _mp_obj_module_t upy_cubeadcs_gen2_cubecomputercommon3_user_cmodule;
#undef MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCOMMON3
#define MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCOMMON3 { MP_ROM_QSTR(MP_QSTR_upy_cubeadcs_gen2_cubecomputercommon3), MP_ROM_PTR(&upy_cubeadcs_gen2_cubecomputercommon3_user_cmodule) },

extern const struct _mp_obj_module_t upy_cubeadcs_gen2_cubecomputercontrolprogram8_user_cmodule;
#undef MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCONTROLPROGRAM8
#define MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCONTROLPROGRAM8 { MP_ROM_QSTR(MP_QSTR_upy_cubeadcs_gen2_cubecomputercontrolprogram8), MP_ROM_PTR(&upy_cubeadcs_gen2_cubecomputercontrolprogram8_user_cmodule) },

extern const struct _mp_obj_module_t upy_fdir_srv_user_cmodule;
#undef MODULE_DEF_UPY_FDIR_SRV
#define MODULE_DEF_UPY_FDIR_SRV { MP_ROM_QSTR(MP_QSTR_upy_fdir_srv), MP_ROM_PTR(&upy_fdir_srv_user_cmodule) },

extern const struct _mp_obj_module_t upy_obc_cubeadcs_gen2_user_cmodule;
#undef MODULE_DEF_UPY_OBC_CUBEADCS_GEN2
#define MODULE_DEF_UPY_OBC_CUBEADCS_GEN2 { MP_ROM_QSTR(MP_QSTR_upy_obc_cubeadcs_gen2), MP_ROM_PTR(&upy_obc_cubeadcs_gen2_user_cmodule) },

extern const struct _mp_obj_module_t upy_payload_ctrl_user_cmodule;
#undef MODULE_DEF_UPY_PAYLOAD_CTRL
#define MODULE_DEF_UPY_PAYLOAD_CTRL { MP_ROM_QSTR(MP_QSTR_upy_payload_ctrl), MP_ROM_PTR(&upy_payload_ctrl_user_cmodule) },

extern const struct _mp_obj_module_t upy_sdr_user_cmodule;
#undef MODULE_DEF_UPY_SDR
#define MODULE_DEF_UPY_SDR { MP_ROM_QSTR(MP_QSTR_upy_sdr), MP_ROM_PTR(&upy_sdr_user_cmodule) },

extern const struct _mp_obj_module_t upy_telemetry_user_cmodule;
#undef MODULE_DEF_UPY_TELEMETRY
#define MODULE_DEF_UPY_TELEMETRY { MP_ROM_QSTR(MP_QSTR_upy_telemetry), MP_ROM_PTR(&upy_telemetry_user_cmodule) },


#define MICROPY_REGISTERED_MODULES \
    MODULE_DEF_BUILTINS \
    MODULE_DEF_FMNG \
    MODULE_DEF_GC \
    MODULE_DEF_MATH \
    MODULE_DEF_MICROPYTHON \
    MODULE_DEF_OBC_COMM_GW \
    MODULE_DEF_SYS \
    MODULE_DEF_UPY_CONOPS \
    MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCOMMON3 \
    MODULE_DEF_UPY_CUBEADCS_GEN2_CUBECOMPUTERCONTROLPROGRAM8 \
    MODULE_DEF_UPY_FDIR_SRV \
    MODULE_DEF_UPY_OBC_CUBEADCS_GEN2 \
    MODULE_DEF_UPY_PAYLOAD_CTRL \
    MODULE_DEF_UPY_SDR \
    MODULE_DEF_UPY_TELEMETRY \
    MODULE_DEF___MAIN__ \
// MICROPY_REGISTERED_MODULES

#define MICROPY_REGISTERED_EXTENSIBLE_MODULES \
    MODULE_DEF_ARRAY \
    MODULE_DEF_COLLECTIONS \
    MODULE_DEF_IO \
    MODULE_DEF_STRUCT \
    MODULE_DEF_TIME \
// MICROPY_REGISTERED_EXTENSIBLE_MODULES

extern void mp_module_sys_attr(mp_obj_t self_in, qstr attr, mp_obj_t *dest);
#define MICROPY_MODULE_DELEGATIONS \
    { MP_ROM_PTR(&mp_module_sys), mp_module_sys_attr }, \
// MICROPY_MODULE_DELEGATIONS
