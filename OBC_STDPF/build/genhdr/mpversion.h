// This file was generated by py/makeversionhdr.py
#define MICROPY_GIT_TAG "36ccbd1-dirty"
#define MICROPY_BUILD_DATE "2026-09-18"
