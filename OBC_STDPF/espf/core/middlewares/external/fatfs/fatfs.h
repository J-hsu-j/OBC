/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file   fatfs.h
  * @brief  Header for fatfs applications
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2021 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/**
 * @addtogroup Middleware
 * @{
 */
/**
 * @defgroup fatfs FAT File System
 *
 * FAT-FS library generated by STM32cubeIDE adapted for the OBC usage.
 *
 * @{
 */

/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __fatfs_H
#define __fatfs_H
#ifdef __cplusplus
 extern "C" {
#endif

#include "integer.h"
#include "sys_time.h"

/** @brief Converts a user provided FATFS date and time to a Unix timestamp
 *  @param[in] fdate FATFS date
 *  @param[in] ftime FATFS time
 *
 *  @note The encoding of fdate and ftime is described here:
 *  http://elm-chan.org/fsw/ff/doc/sfileinfo.html
 *
 *  @return Unix timestamp value based on fdate and ftime
 * */
unix_time_t fattime_to_unix(const WORD fdate, const WORD ftime);
#ifdef __cplusplus
}
#endif
#endif /*__fatfs_H */

/**
 * @{
 * @{
 */
